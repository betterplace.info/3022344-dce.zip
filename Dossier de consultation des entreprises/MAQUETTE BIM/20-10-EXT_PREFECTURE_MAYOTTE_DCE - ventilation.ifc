Properties of the parts of a building model (IFC2X3), part 4 of 7

# IfcDistributionPort (6159)
Name | FlowDirection | Group
2 x OutPort_8468694 | SOURCEANDSINK | M5448FF 1
2 x InPort_8468669 | SOURCEANDSINK | M5448FF 1
2 x OutPort_8468917 | SOURCEANDSINK | M5448FF 1
2 x InPort_8468714 | SOURCEANDSINK | M5448FF 2
2 x OutPort_8468743 | SOURCEANDSINK | M5448FF 2
2 x InPort_8468724 | SOURCEANDSINK | M5448FF 2
2 x OutPort_8468997 | SOURCEANDSINK | M5448FF 2
2 x InPort_8468915 | SOURCEANDSINK | M5448FF 1
InPort_8468917 | SOURCEANDSINK | M5448FF 1
OutPort_8468918 | SOURCEANDSINK | M5448FF 1
InPort_8468918 | SOURCEANDSINK | M5448FF 1
2 x OutPort_8468961 | SOURCEANDSINK | M5448FF 1
2 x InPort_8468959 | SOURCEANDSINK | M5448FF 1
InPort_8468961 | SOURCEANDSINK | M5448FF 1
2 x InPort_8468995 | SOURCEANDSINK | M5448FF 2
InPort_8468997 | SOURCEANDSINK | M5448FF 2
OutPort_8468998 | SOURCEANDSINK | M5448FF 2
InPort_8468998 | SOURCEANDSINK | M5448FF 2
2 x OutPort_8469037 | SOURCEANDSINK | M5448FF 2
2 x InPort_8469035 | SOURCEANDSINK | M5448FF 2
InPort_8469037 | SOURCEANDSINK | M5448FF 2
2 x InPort_8469652 | SOURCEANDSINK | M5448FF 16
2 x OutPort_8471284 | SOURCEANDSINK | M5448FF 16
2 x InPort_8469660 | SOURCEANDSINK | M5448FF 16
2 x OutPort_8471349 | SOURCEANDSINK | M5448FF 16
2 x InPort_8469697 | SOURCEANDSINK | M5448FF 15
2 x OutPort_8471263 | SOURCEANDSINK | M5448FF 15
2 x InPort_8469705 | SOURCEANDSINK | M5448FF 15
2 x OutPort_8471377 | SOURCEANDSINK | M5448FF 15
2 x InPort_8469908 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8469924 | SOURCEANDSINK | M5448FF 10
2 x InPort_8469918 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8469972 | SOURCEANDSINK | M5448FF 10
2 x InPort_8469956 | SOURCEANDSINK | M5448FF 10
InPort_8469966 | SOURCEANDSINK | M5448FF 10
2 x InPort_8470017 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8470033 | SOURCEANDSINK | M5448FF 9
2 x InPort_8470027 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8470051 | SOURCEANDSINK | M5448FF 9
2 x InPort_8470035 | SOURCEANDSINK | M5448FF 9
InPort_8470045 | SOURCEANDSINK | M5448FF 9
2 x InPort_8470253 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8470383 | SOURCEANDSINK | M5448FF 9
2 x InPort_8470288 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8470424 | SOURCEANDSINK | M5448FF 10
2 x InPort_8470373 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8470391 | SOURCEANDSINK | M5448FF 9
2 x InPort_8470385 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8470401 | SOURCEANDSINK | M5448FF 9
InPort_8470393 | SOURCEANDSINK | M5448FF 9
Port_8470393 | SOURCEANDSINK | M5448FF 9
2 x InPort_8470416 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8470432 | SOURCEANDSINK | M5448FF 10
2 x InPort_8470426 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8470442 | SOURCEANDSINK | M5448FF 10
Port_8470434 | SOURCEANDSINK | M5448FF 10
InPort_8470434 | SOURCEANDSINK | M5448FF 10
2 x InPort_8470853 | SOURCEANDSINK | M5448FF 2
2 x OutPort_8470948 | SOURCEANDSINK | M5448FF 2
2 x InPort_8470863 | SOURCEANDSINK | M5448FF 2
2 x OutPort_8470950 | SOURCEANDSINK | M5448FF 2
2 x InPort_8470886 | SOURCEANDSINK | M5448FF 1
2 x OutPort_8470982 | SOURCEANDSINK | M5448FF 1
2 x InPort_8470896 | SOURCEANDSINK | M5448FF 1
2 x OutPort_8470984 | SOURCEANDSINK | M5448FF 1
InPort_8470943 | SOURCEANDSINK | M5448FF 2
InPort_8470950 | SOURCEANDSINK | M5448FF 2
InPort_8470977 | SOURCEANDSINK | M5448FF 1
InPort_8470984 | SOURCEANDSINK | M5448FF 1
2 x InPort_8471049 | SOURCEANDSINK | M5448FF 14
2 x OutPort_8471164 | SOURCEANDSINK | M5448FF 14
2 x InPort_8471095 | SOURCEANDSINK | M5448FF 13
2 x OutPort_8471130 | SOURCEANDSINK | M5448FF 13
2 x InPort_8471122 | SOURCEANDSINK | M5448FF 13
2 x OutPort_8472701 | SOURCEANDSINK | M5448FF 13
2 x InPort_8471156 | SOURCEANDSINK | M5448FF 14
2 x OutPort_8472778 | SOURCEANDSINK | M5448FF 14
Port_8471339 | SOURCEANDSINK | M5448FF 16
InPort_8471339 | SOURCEANDSINK | M5448FF 16
InPort_8471367 | SOURCEANDSINK | M5448FF 15
Port_8471367 | SOURCEANDSINK | M5448FF 15
InPort_8471454 | SOURCEANDSINK | M531 3
InPort_8471531 | SOURCEANDSINK | M531 3
Port_8471894 | SOURCEANDSINK | M5448FF 13
InPort_8471894 | SOURCEANDSINK | M5448FF 13
InPort_8472204 | SOURCEANDSINK | M5448FF 14
Port_8472204 | SOURCEANDSINK | M5448FF 14
2 x InPort_8472693 | SOURCEANDSINK | M5448FF 13
2 x OutPort_8472801 | SOURCEANDSINK | M5448FF 13
2 x InPort_8472770 | SOURCEANDSINK | M5448FF 14
2 x OutPort_8472832 | SOURCEANDSINK | M5448FF 14
2 x InPort_8472793 | SOURCEANDSINK | M5448FF 13
2 x OutPort_8472811 | SOURCEANDSINK | M5448FF 13
InPort_8472803 | SOURCEANDSINK | M5448FF 13
Port_8472803 | SOURCEANDSINK | M5448FF 13
2 x InPort_8472824 | SOURCEANDSINK | M5448FF 14
2 x OutPort_8472842 | SOURCEANDSINK | M5448FF 14
InPort_8472834 | SOURCEANDSINK | M5448FF 14
Port_8472834 | SOURCEANDSINK | M5448FF 14
2 x InPort_8473415 | SOURCEANDSINK | M531 3
InPort_8473417 | SOURCEANDSINK | M531 3
InPort_8473543 | SOURCEANDSINK | M531 3
2 x InPort_8473605 | SOURCEANDSINK | M531 3
2 x OutPort_8714191 | SOURCEANDSINK | M531 3
2 x InPort_8474586 | SOURCEANDSINK | M531 3
2 x OutPort_8474716 | SOURCEANDSINK | M531 3
2 x InPort_8474602 | SOURCEANDSINK | M531 3
OutPort_8474718 | SOURCEANDSINK | M531 3
InPort_8474718 | SOURCEANDSINK | M531 3
OutPort_8474719 | SOURCEANDSINK | M531 3
InPort_8474719 | SOURCEANDSINK | M531 3
2 x OutPort_8474743 | SOURCEANDSINK | M531 3
2 x InPort_8474733 | SOURCEANDSINK | M531 3
2 x OutPort_8474773 | SOURCEANDSINK | M531 3
InPort_8474743 | SOURCEANDSINK | M531 3
OutPort_8474744 | SOURCEANDSINK | M531 3
InPort_8474744 | SOURCEANDSINK | M531 3
2 x OutPort_8475206 | SOURCEANDSINK | M531 3
2 x InPort_8474763 | SOURCEANDSINK | M531 3
2 x OutPort_8474783 | SOURCEANDSINK | M531 3
InPort_8474775 | SOURCEANDSINK | M531 3
Port_8474775 | SOURCEANDSINK | M531 3
InPort_8474871 | SOURCEANDSINK | M532F 6
2 x OutPort_8474906 | SOURCEANDSINK | M532F 6
Port_8474871 | SOURCEANDSINK | M532F 6
2 x InPort_8474898 | SOURCEANDSINK | M532F 6
2 x OutPort_8474916 | SOURCEANDSINK | M532F 6
2 x InPort_8474908 | SOURCEANDSINK | M532F 6
OutPort_8474924 | SOURCEANDSINK | M532F 6
InPort_8474918 | SINK | M532F 6
OutPort_8474979 | SOURCE | M532F 6
InPort_8474995 | SINK | M532F 6
OutPort_8474918 | SOURCE | M532F 6
InPort_8474924 | SOURCEANDSINK | M532F 6
2 x OutPort_8474951 | SOURCEANDSINK | M532F 6
Port_8474940 | SOURCEANDSINK | M532F 6
InPort_8474940 | SOURCEANDSINK | M532F 6
OutPort_8474950 | SOURCEANDSINK | M532F 6
2 x InPort_8474950 | SOURCEANDSINK | M532F 6
2 x OutPort_8474980 | SOURCEANDSINK | M532F 6
Port_8474971 | SOURCEANDSINK | M532F 6
InPort_8474971 | SOURCEANDSINK | M532F 6
OutPort_8474979 | SOURCEANDSINK | M532F 6
InPort_8474979 | SOURCEANDSINK | M532F 6
InPort_8475198 | SOURCEANDSINK | M531 3
Port_8475198 | SOURCEANDSINK | M531 3
InPort_8475206 | SOURCEANDSINK | M531 3
OutPort_8475207 | SOURCEANDSINK | M531 3
InPort_8475207 | SOURCEANDSINK | M531 3
2 x OutPort_8475229 | SOURCEANDSINK | M531 3
InPort_8475221 | SOURCEANDSINK | M531 3
Port_8475221 | SOURCEANDSINK | M531 3
InPort_8475229 | SOURCEANDSINK | M531 3
OutPort_8475230 | SOURCEANDSINK | M531 3
InPort_8475230 | SOURCEANDSINK | M531 3
2 x OutPort_8475253 | SOURCEANDSINK | M531 3
Port_8475245 | SOURCEANDSINK | M531 3
InPort_8475245 | SOURCEANDSINK | M531 3
InPort_8475253 | SOURCEANDSINK | M531 3
2 x Port_8475353 | SOURCEANDSINK | M532F 7
2 x Port_8476548 | SOURCEANDSINK | M532F 8
2 x Port_8476765 | SOURCEANDSINK | M531 7
2 x Port_8476814 | SOURCEANDSINK | M531 8
2 x Port_8476879 | SOURCEANDSINK | M531 9
InPort_8479215 | SOURCEANDSINK | M531 3
2 x InPort_8479220 | SOURCEANDSINK | M531 3
2 x OutPort_8480171 | SOURCEANDSINK | M531 3
2 x InPort_8479279 | SOURCEANDSINK | M531 3
2 x OutPort_8479792 | SOURCEANDSINK | M531 3
2 x InPort_8479756 | SOURCEANDSINK | M531 3
Port_8479954 | SOURCEANDSINK | M531 3
InPort_8479954 | SOURCEANDSINK | M531 3
Port_8480033 | SOURCEANDSINK | M531 3
InPort_8480033 | SOURCEANDSINK | M531 3
Port_8480124 | SOURCEANDSINK | M531 3
InPort_8480124 | SOURCEANDSINK | M531 3
InPort_8480170 | SOURCEANDSINK | M531 3
InPort_8480455 | SOURCEANDSINK | M531 3
InPort_8480473 | SOURCEANDSINK | M531 3
Port_8480628 | SOURCEANDSINK | M531 3
InPort_8480628 | SOURCEANDSINK | M531 3
InPort_8481069 | SOURCEANDSINK | M531 3
OutPort_8481070 | SOURCEANDSINK | M531 3
InPort_8481070 | SOURCEANDSINK | M531 3
2 x OutPort_8481797 | SOURCEANDSINK | M531 3
InPort_8481129 | SOURCEANDSINK | M531 3
OutPort_8481155 | SOURCEANDSINK | M531 3
InPort_8481155 | SOURCEANDSINK | M531 3
InPort_8481167 | SOURCEANDSINK | M531 3
OutPort_8481597 | SOURCEANDSINK | M531 3
2 x InPort_8481172 | SOURCEANDSINK | M531 3
InPort_8481448 | SOURCEANDSINK | M531 3
InPort_8481475 | SOURCEANDSINK | M531 3
InPort_8481597 | SOURCEANDSINK | M531 3
2 x OutPort_8481825 | SOURCEANDSINK | M531 3
2 x InPort_8481789 | SOURCEANDSINK | M531 3
InPort_8482005 | SOURCEANDSINK | M531 3
Port_8482005 | SOURCEANDSINK | M531 3
Port_8482027 | SOURCEANDSINK | M531 3
InPort_8482027 | SOURCEANDSINK | M531 3
Port_8482053 | SOURCEANDSINK | M531 3
InPort_8482053 | SOURCEANDSINK | M531 3
InPort_8482754 | SOURCEANDSINK | M531 3
2 x OutPort_8482812 | SOURCEANDSINK | M531 3
2 x InPort_8482756 | SOURCEANDSINK | M531 3
OutPort_8482806 | SOURCEANDSINK | M531 3
2 x InPort_8482771 | SOURCEANDSINK | M531 3
2 x OutPort_8482811 | SOURCEANDSINK | M531 3
InPort_8482806 | SOURCEANDSINK | M531 3
InPort_8482811 | SOURCEANDSINK | M531 3
InPort_8482847 | SOURCEANDSINK | M531 3
OutPort_8482904 | SOURCEANDSINK | M531 3
2 x InPort_8482896 | SOURCEANDSINK | M531 3
2 x OutPort_8483928 | SOURCEANDSINK | M531 3
InPort_8482904 | SOURCEANDSINK | M531 3
2 x OutPort_8483929 | SOURCEANDSINK | M531 3
Port_8483183 | SOURCEANDSINK | M531 3
InPort_8483183 | SOURCEANDSINK | M531 3
2 x OutPort_8483926 | SOURCEANDSINK | M531 3
2 x InPort_8483275 | SOURCEANDSINK | M531 3
Port_8483371 | SOURCEANDSINK | M531 3
InPort_8483371 | SOURCEANDSINK | M531 3
InPort_8483759 | SOURCEANDSINK | M532F 4
OutPort_8483850 | SOURCEANDSINK | M532F 4
InPort_8483850 | SOURCEANDSINK | M532F 4
2 x OutPort_8483866 | SOURCEANDSINK | M532F 4
Port_8483858 | SOURCEANDSINK | M532F 4
InPort_8483858 | SOURCEANDSINK | M532F 4
Port_8483886 | SOURCEANDSINK | M532F 4
InPort_8483886 | SOURCEANDSINK | M532F 4
InPort_8483928 | SOURCEANDSINK | M531 3
InPort_8483980 | SINK | Génie climatique Soufflage 40
OutPort_8483979 | SOURCE | Génie climatique Soufflage 40
3 x Port_8483979 | SOURCEANDSINK
InPort_8483979 | SINK | Génie climatique Reprise 1
OutPort_8485234 | SOURCE | Génie climatique Reprise 1
InPort_8483981 | SINK | Génie climatique Soufflage 40
OutPort_8483980 | SOURCE | Génie climatique Soufflage 40
2 x InPort_8485234 | SINK | Génie climatique Reprise 1
OutPort_8507966 | SOURCE | Génie climatique Reprise 1
OutPort_8486597 | SOURCE | Génie climatique Reprise 1
InPort_8485655 | SINK | Génie climatique Reprise 1
OutPort_8507964 | SOURCE | Génie climatique Reprise 1
InPort_8507966 | SINK | Génie climatique Reprise 1
OutPort_8485655 | SOURCE | Génie climatique Reprise 1
InPort_8507964 | SINK | Génie climatique Reprise 1
OutPort_8485679 | SOURCE | Génie climatique Reprise 1
InPort_8485679 | SINK | Génie climatique Reprise 1
OutPort_8507145 | SOURCE | Génie climatique Reprise 1
Port_8497764 | SOURCEANDSINK | M5232 5
InPort_8497764 | SOURCEANDSINK | M5232 5
2 x OutPort_8498545 | SOURCEANDSINK | M5232 5
Port_8497774 | SOURCEANDSINK | M5448FF 9
InPort_8497774 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8498287 | SOURCEANDSINK | M5448FF 9
InPort_8497781 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8498239 | SOURCEANDSINK | M5448FF 10
Port_8497781 | SOURCEANDSINK | M5448FF 10
InPort_8498206 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8498502 | SOURCEANDSINK | M5448FF 10
InPort_8498218 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8498459 | SOURCEANDSINK | M5448FF 9
2 x InPort_8498229 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8498498 | SOURCEANDSINK | M5448FF 10
2 x InPort_8498241 | SOURCEANDSINK | M5448FF 10
2 x OutPort_8498501 | SOURCEANDSINK | M5448FF 10
2 x InPort_8498277 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8498455 | SOURCEANDSINK | M5448FF 9
2 x InPort_8498289 | SOURCEANDSINK | M5448FF 9
2 x OutPort_8498458 | SOURCEANDSINK | M5448FF 9
InPort_8498448 | SOURCEANDSINK | M5448FF 9
InPort_8498458 | SOURCEANDSINK | M5448FF 9
InPort_8498486 | SOURCEANDSINK | M5448FF 10
InPort_8498501 | SOURCEANDSINK | M5448FF 10
2 x InPort_8498532 | SOURCEANDSINK | M5232 5
2 x OutPort_8498564 | SOURCEANDSINK | M5232 5
2 x InPort_8498549 | SOURCEANDSINK | M5232 5
2 x OutPort_8498760 | SOURCEANDSINK | M5232 5
2 x InPort_8498684 | SOURCEANDSINK | M5232 5
2 x OutPort_8498781 | SOURCEANDSINK | M5232 5
2 x InPort_8498771 | SOURCEANDSINK | M5232 5
2 x OutPort_8498813 | SOURCEANDSINK | M5232 5
2 x InPort_8498783 | SOURCEANDSINK | M5232 5
InPort_8498802 | SOURCEANDSINK | M5232 5
InPort_8499069 | SINK | M5232 4
OutPort_8499067 | SOURCE | M5232 4
Port_8499067 | SOURCE | M5232 4
InPort_8499070 | SINK | M5232 5
OutPort_8499069 | SOURCE | M5232 5
InPort_8499372 | SINK | M5232 5
OutPort_8499070 | SOURCE | M5232 5
InPort_8499362 | SINK | M5232 5
OutPort_8499372 | SOURCE | M5232 5
InPort_8499385 | SINK | M5232 5
OutPort_8499362 | SOURCE | M5232 5
InPort_8499960 | SINK | M5232 5
OutPort_8499376 | SOURCE | M5232 5
InPort_8499376 | SINK | M5232 5
OutPort_8499385 | SOURCE | M5232 5
InPort_8499808 | SINK | M5232 5
OutPort_8499960 | SOURCE | M5232 5
InPort_8500070 | SINK | M5232 5
OutPort_8499808 | SOURCE | M5232 5
InPort_8500074 | SINK | M5232 5
OutPort_8499977 | SOURCE | M5232 5
InPort_8499977 | SINK | M5232 5
OutPort_8500070 | SOURCE | M5232 5
InPort_8500059 | SOURCEANDSINK | M5232 5
OutPort_8500074 | SOURCEANDSINK | M5232 5
InPort_8500074 | SOURCEANDSINK | M5232 5
InPort_8507145 | SINK | Génie climatique Reprise 1
OutPort_8507142 | SOURCE | Génie climatique Reprise 1
InPort_8519241 | SINK | M570HR 1
OutPort_8519243 | SOURCE | M570HR 1
2 x InPort_8519283 | SINK | M570HR 1
OutPort_8519241 | SOURCE | M570HR 1
InPort_8519243 | SINK | M570HR 1
OutPort_8519244 | SOURCE | M570HR 1
InPort_8519244 | SINK | M570HR 1
OutPort_8847732 | SOURCE | M570HR 1
OutPort_8519284 | SOURCE | M570HR 1
InPort_8570071 | SINK | M570HR 2
OutPort_8570073 | SOURCE | M570HR 2
InPort_8570073 | SINK | M570HR 2
OutPort_8833910 | SOURCE | M570HR 2
Port_8572477 | SINK | M570HR 4
InPort_8572477 | SINK | M570HR 4
OutPort_8572500 | SOURCE | M570HR 4
InPort_8607082 | SINK | M570HR 3
OutPort_8835701 | SOURCE | M570HR 3
Port_8607082 | SINK | M570HR 3
InPort_8611118 | SINK | M570HR 1
OutPort_8611167 | SOURCE | M570HR 1
InPort_8611171 | SINK | M570HR 1
OutPort_8611118 | SOURCE | M570HR 1
InPort_8611419 | SINK | M570HR 1
OutPort_8611171 | SOURCE | M570HR 1
2 x InPort_8611418 | SINK | M570HR 1
OutPort_8611280 | SOURCE | M570HR 1
InPort_8611280 | SINK | M570HR 1
OutPort_8611432 | SOURCE | M570HR 1
InPort_8611503 | SINK | M570HR 1
OutPort_8611418 | SOURCE | M570HR 1
OutPort_8611419 | SOURCE | M570HR 1
InPort_8611463 | SINK | M570HR 1
OutPort_8611508 | SOURCE | M570HR 1
2 x InPort_8611502 | SINK | M570HR 1
OutPort_8611463 | SOURCE | M570HR 1
OutPort_8611503 | SOURCE | M570HR 1
2 x InPort_8630857 | SOURCEANDSINK | M531 10
2 x OutPort_8630958 | SOURCEANDSINK | M531 10
2 x OutPort_8630878 | SOURCEANDSINK | M531 10
Port_8630870 | SOURCEANDSINK | M531 10
InPort_8630870 | SOURCEANDSINK | M531 10
2 x InPort_8630945 | SOURCEANDSINK | M531 10
2 x OutPort_8630998 | SOURCEANDSINK | M531 10
InPort_8630958 | SOURCEANDSINK | M531 10
OutPort_8630959 | SOURCEANDSINK | M531 10
InPort_8630959 | SOURCEANDSINK | M531 10
2 x OutPort_8714062 | SOURCEANDSINK | M531 10
2 x InPort_8630963 | SOURCEANDSINK | M531 10
2 x OutPort_8631098 | SOURCEANDSINK | M531 10
2 x InPort_8631016 | SOURCEANDSINK | M531 10
2 x OutPort_8631113 | SOURCEANDSINK | M531 10
2 x InPort_8631103 | SOURCEANDSINK | M531 10
2 x OutPort_8631128 | SOURCEANDSINK | M531 10
2 x InPort_8631117 | SOURCEANDSINK | M531 10
2 x OutPort_8631204 | SOURCEANDSINK | M531 10
Port_8631198 | SOURCEANDSINK | M531 10
InPort_8631198 | SOURCEANDSINK | M531 10
Port_8682794 | SINK
Port_8682794 | SOURCE
2 x Port_8695419 | SOURCEANDSINK
2 x InPort_8696763 | SOURCEANDSINK | M531 3
OutPort_8696829 | SOURCEANDSINK | M531 3
2 x OutPort_8696818 | SOURCEANDSINK | M531 3
InPort_8696806 | SOURCEANDSINK | M531 3
InPort_8696818 | SOURCEANDSINK | M531 3
InPort_8696829 | SOURCEANDSINK | M531 3
OutPort_8696831 | SOURCEANDSINK | M531 3
InPort_8696831 | SOURCEANDSINK | M531 3
2 x OutPort_8696985 | SOURCEANDSINK | M531 3
Port_8696979 | SOURCEANDSINK | M531 3
InPort_8696979 | SOURCEANDSINK | M531 3
InPort_8697375 | SINK | M5232 22
OutPort_8697157 | SOURCE | M5232 22
InPort_8697426 | SINK | M5232 22
OutPort_8697375 | SOURCE | M5232 22
InPort_8697668 | SINK | M5232 22
OutPort_8697412 | SOURCE | M5232 22
InPort_8697412 | SINK | M5232 22
OutPort_8697426 | SOURCE | M5232 22
2 x InPort_8697672 | SINK | M5232 22
OutPort_8697479 | SOURCE | M5232 22
InPort_8697479 | SINK | M5232 22
OutPort_8697668 | SOURCE | M5232 22
InPort_8697659 | SINK | M5232 22
OutPort_8697672 | SOURCE | M5232 22
OutPort_8697673 | SOURCE | M5232 22
InPort_8714054 | SOURCEANDSINK | M531 10
Port_8714054 | SOURCEANDSINK | M531 10
InPort_8714183 | SOURCEANDSINK | M531 3
Port_8714183 | SOURCEANDSINK | M531 3
OutPort_8833528 | SOURCE | M570HR 2
InPort_8833541 | SINK | M570HR 2
OutPort_8833303 | SOURCE | M570HR 2
InPort_8833530 | SINK | M570HR 2
OutPort_8833541 | SOURCE | M570HR 2
InPort_8833909 | SINK | M570HR 2
OutPort_8833530 | SOURCE | M570HR 2
InPort_8833545 | SINK | M570HR 2
OutPort_8833909 | SOURCE | M570HR 2
InPort_8833910 | SINK | M570HR 2
OutPort_8833545 | SOURCE | M570HR 2
InPort_8835699 | SINK | M570HR 3
OutPort_8834246 | SOURCE | M570HR 3
InPort_8834246 | SINK | M570HR 3
OutPort_8835348 | SOURCE | M570HR 3
InPort_8835701 | SINK | M570HR 3
OutPort_8834285 | SOURCE | M570HR 3
InPort_8834285 | SINK | M570HR 3
OutPort_8835699 | SOURCE | M570HR 3
Port_8835348 | SOURCEANDSINK
InPort_8835348 | SINK | M570HR 2
OutPort_8835426 | SOURCE | M570HR 2
Port_8836510 | SINK | VMC 1
InPort_8837334 | SINK | M570HR 2
OutPort_8837291 | SOURCE | M570HR 2
InPort_8837515 | SINK | M570HR 2
OutPort_8837334 | SOURCE | M570HR 2
OutPort_8837515 | SOURCE | M570HR 2
InPort_8837510 | SINK | M570HR 2
OutPort_8837509 | SOURCE | M570HR 2
2 x InPort_8837879 | SOURCEANDSINK | M5232 1
OutPort_8838054 | SOURCEANDSINK | M5232 1
InPort_8838054 | SOURCEANDSINK | M5232 1
2 x OutPort_8840697 | SOURCEANDSINK | M5232 1
2 x InPort_8839709 | SOURCEANDSINK | M5232 1
2 x InPort_8840308 | SOURCEANDSINK | M5232 1
2 x InPort_8840430 | SOURCEANDSINK | M5232 1
2 x OutPort_8840696 | SOURCEANDSINK | M5232 1
2 x InPort_8840687 | SOURCEANDSINK | M5232 1
OutPort_8842687 | SOURCEANDSINK | M5232 1
InPort_8840696 | SOURCEANDSINK | M5232 1
2 x InPort_8841167 | SOURCEANDSINK | M5232 1
2 x InPort_8841329 | SOURCEANDSINK | M5232 1
OutPort_8841347 | SOURCEANDSINK | M5232 1
2 x InPort_8841341 | SOURCEANDSINK | M5232 1
2 x OutPort_8842237 | SOURCEANDSINK | M5232 1
2 x OutPort_8842567 | SOURCEANDSINK | M5232 1
InPort_8841347 | SOURCEANDSINK | M5232 1
2 x OutPort_8842238 | SOURCEANDSINK | M5232 1
2 x InPort_8842076 | SOURCEANDSINK | M5232 1
2 x InPort_8842112 | SOURCEANDSINK | M5232 1
2 x OutPort_8842182 | SOURCEANDSINK | M5232 1
2 x InPort_8842174 | SOURCEANDSINK | M5232 1
2 x OutPort_8842242 | SOURCEANDSINK | M5232 1
2 x InPort_8842222 | SOURCEANDSINK | M5232 1
InPort_8842237 | SOURCEANDSINK | M5232 1
Port_8842423 | SOURCEANDSINK | M5232 1
InPort_8842423 | SOURCEANDSINK | M5232 1
OutPort_8843772 | SOURCEANDSINK | M5232 1
2 x InPort_8842559 | SOURCEANDSINK | M5232 1
2 x OutPort_8842577 | SOURCEANDSINK | M5232 1
2 x InPort_8842571 | SOURCEANDSINK | M5232 1
2 x OutPort_8842791 | SOURCEANDSINK | M5232 1
2 x InPort_8842687 | SOURCEANDSINK | M5232 1
OutPort_8842688 | SOURCEANDSINK | M5232 1
2 x OutPort_8846643 | SOURCEANDSINK | M5232 1
InPort_8842688 | SOURCEANDSINK | M5232 1
2 x OutPort_8842795 | SOURCEANDSINK | M5232 1
2 x InPort_8842745 | SOURCEANDSINK | M5232 1
InPort_8842795 | SOURCEANDSINK | M5232 1
OutPort_8842796 | SOURCEANDSINK | M5232 1
InPort_8842796 | SOURCEANDSINK | M5232 1
2 x OutPort_8852279 | SOURCEANDSINK | M5232 1
2 x InPort_8843577 | SOURCEANDSINK | M5232 1
2 x InPort_8843683 | SOURCEANDSINK | M5232 1
OutPort_8843768 | SOURCEANDSINK | M5232 1
InPort_8843768 | SOURCEANDSINK | M5232 1
2 x OutPort_8844561 | SOURCEANDSINK | M5232 1
2 x InPort_8843772 | SOURCEANDSINK | M5232 1
OutPort_8844551 | SOURCEANDSINK | M5232 1
OutPort_8843773 | SOURCEANDSINK | M5232 1
InPort_8843773 | SOURCEANDSINK | M5232 1
2 x OutPort_8846642 | SOURCEANDSINK | M5232 1
2 x InPort_8843863 | SOURCEANDSINK | M5232 1
2 x OutPort_8844560 | SOURCEANDSINK | M5232 1
2 x InPort_8844281 | SOURCEANDSINK | M5232 1
InPort_8844551 | SOURCEANDSINK | M5232 1
InPort_8844560 | SOURCEANDSINK | M5232 1
2 x InPort_8845106 | SOURCEANDSINK | M5232 1
2 x InPort_8845144 | SOURCEANDSINK | M5232 1
OutPort_8845168 | SOURCEANDSINK | M5232 1
InPort_8845168 | SOURCEANDSINK | M5232 1
2 x OutPort_8845651 | SOURCEANDSINK | M5232 1
2 x InPort_8845565 | SOURCEANDSINK | M5232 1
2 x OutPort_8845646 | SOURCEANDSINK | M5232 1
2 x InPort_8845598 | SOURCEANDSINK | M5232 1
OutPort_8845650 | SOURCEANDSINK | M5232 1
2 x InPort_8845650 | SOURCEANDSINK | M5232 1
2 x OutPort_8846352 | SOURCEANDSINK | M5232 1
2 x InPort_8845690 | SOURCEANDSINK | M5232 1
2 x OutPort_8845820 | SOURCEANDSINK | M5232 1
2 x InPort_8845812 | SOURCEANDSINK | M5232 1
2 x OutPort_8845828 | SOURCEANDSINK | M5232 1
2 x InPort_8845822 | SOURCEANDSINK | M5232 1
2 x OutPort_8846347 | SOURCEANDSINK | M5232 1
2 x InPort_8845889 | SOURCEANDSINK | M5232 1
2 x OutPort_8846351 | SOURCEANDSINK | M5232 1
2 x InPort_8846340 | SOURCEANDSINK | M5232 1
2 x OutPort_8846377 | SOURCEANDSINK | M5232 1
InPort_8846351 | SOURCEANDSINK | M5232 1
2 x InPort_8846369 | SOURCEANDSINK | M5232 1
2 x OutPort_8846390 | SOURCEANDSINK | M5232 1
2 x InPort_8846381 | SOURCEANDSINK | M5232 1
2 x OutPort_8846650 | SOURCEANDSINK | M5232 1
2 x InPort_8846630 | SOURCEANDSINK | M5232 1
InPort_8846642 | SOURCEANDSINK | M5232 1
InPort_8850766 | SINK | M570HR 1
OutPort_8850117 | SOURCE | M570HR 1
InPort_8850620 | SINK | M570HR 1
OutPort_8850619 | SOURCE | M570HR 1
OutPort_8850624 | SOURCE | M570HR 1
3 x Port_8852006 | SOURCEANDSINK
Port_8852006 | SOURCE
Port_8852006 | SINK
Port_8852095 | SOURCEANDSINK | M5232 1
InPort_8852095 | SOURCEANDSINK | M5232 1
2 x InPort_8864265 | SOURCEANDSINK | M5448FF 5
OutPort_8864279 | SOURCEANDSINK | M5448FF 5
InPort_8864279 | SOURCEANDSINK | M5448FF 5
2 x OutPort_8864321 | SOURCEANDSINK | M5448FF 5
2 x InPort_8864308 | SOURCEANDSINK | M5448FF 5
InPort_8864320 | SOURCEANDSINK | M5448FF 5
2 x InPort_8864356 | SOURCEANDSINK | M5448FF 5
InPort_8879361 | SINK | M5232 15
OutPort_8879375 | SOURCE | M5232 15
InPort_8879377 | SINK | M5232 15
OutPort_8879361 | SOURCE | M5232 15
InPort_8879372 | SOURCEANDSINK | M5232 15
OutPort_8879377 | SOURCEANDSINK | M5232 15
InPort_8879377 | SOURCEANDSINK | M5232 15
2 x InPort_8890890 | SOURCEANDSINK | M5448FF 10
InPort_8891322 | SINK | M570HR 1
OutPort_8891347 | SOURCE | M570HR 1
InPort_8891332 | SINK | M570HR 1
OutPort_8891322 | SOURCE | M570HR 1
InPort_8891347 | SINK | M570HR 1
OutPort_8891335 | SOURCE | M570HR 1
2 x InPort_8891387 | SOURCEANDSINK | M5232 5
2 x OutPort_8891452 | SOURCEANDSINK | M5232 5
2 x InPort_8891403 | SOURCEANDSINK | M5232 5
2 x InPort_8891584 | SOURCEANDSINK | M5232 5
2 x OutPort_8891633 | SOURCEANDSINK | M5232 5
2 x InPort_8891598 | SOURCEANDSINK | M5232 5
2 x InPort_8892000 | SOURCEANDSINK | M5232 5
2 x OutPort_8892131 | SOURCEANDSINK | M5232 5
2 x InPort_8892027 | SOURCEANDSINK | M5232 5
2 x InPort_8892513 | SOURCEANDSINK | M5232 15
InPort_8892782 | SINK | M570HR 1
OutPort_8892813 | SOURCE | M570HR 1
InPort_8892813 | SINK | M570HR 1
OutPort_8892800 | SOURCE | M570HR 1
InPort_8892800 | SINK | M570HR 1
OutPort_8892832 | SOURCE | M570HR 1
InPort_8892832 | SINK | M570HR 1
OutPort_8892818 | SOURCE | M570HR 1
InPort_8895215 | SINK | M570HR 1
OutPort_8893125 | SOURCE | M570HR 1
InPort_8893125 | SINK | M570HR 1
OutPort_8895737 | SOURCE | M570HR 1
InPort_8895706 | SINK | M570HR 1
OutPort_8895214 | SOURCE | M570HR 1
3 x InPort_8895737 | SINK | M570HR 1
OutPort_8895706 | SOURCE | M570HR 1
OutPort_8895771 | SOURCE | M570HR 1
OutPort_8895741 | SOURCE | M570HR 1

# IfcFlowController: 1/2 (3)
In: S02
Type - PredefinedType: FAUCET
Pset_DistributionFlowElementCommon - Reference: 1/2; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Name (Robinet puisage:1/2:...)
8443568
8443836
8444429

# IfcFlowController: 22 mm (6)
Pset_DistributionFlowElementCommon - Reference: 22 mm; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories
Group: M531 3
Name (EG-ACCA_Vannes_Isolement 50-150 mm:22 mm:...) | In
8466698 | 01
8467697 | 01
8468186 | S01
8471454 | 01
8471531 | S02
8473543 | S02

# IfcFlowController: Clapet coupe-feu_125 (2)
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_125; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 1
Name (VE_Valve_Round Fire_MEPcontent_Gaine d'Air Générique_Fire protection valve:Clapet coupe-feu_125:...) | In
8417510 | S01
8418025 | 01

# IfcFlowController: Clapet coupe-feu_200, VE_Valve_Round Fire_MEPcontent_Gaine d'Air Générique_Fire protection valve:Clapet coupe-feu_200:7821710
In: 01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_200; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 2

# IfcFlowController: Clapet coupe-feu_250 (2)
In: 01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_250; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 1
Name (VE_Valve_Round Fire_MEPcontent_Gaine d'Air Générique_Fire protection valve:Clapet coupe-feu_250:...)
7813138
7815834

# IfcFlowController: Clapet coupe-feu_300_250, VE_Valve_Rectangular Fire_MEPcontent_Gaine d'Air Générique:Clapet coupe-feu_300_250:8417191
In: S01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_300_250; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 1

# IfcFlowController: Clapet coupe-feu_315, VE_Valve_Round Fire_MEPcontent_Gaine d'Air Générique_Fire protection valve:Clapet coupe-feu_315:7824340
In: 01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_315; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 1

# IfcFlowController: Clapet coupe-feu_350_250, VE_Valve_Rectangular Fire_MEPcontent_Gaine d'Air Générique:Clapet coupe-feu_350_250:8421820
In: S01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_350_250; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 2

# IfcFlowController: Clapet coupe-feu_400_250, VE_Valve_Rectangular Fire_MEPcontent_Gaine d'Air Générique:Clapet coupe-feu_400_250:8570071
In: S02
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_400_250; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 2

# IfcFlowController: Clapet coupe-feu_400_300, VE_Valve_Rectangular Fire_MEPcontent_Gaine d'Air Générique:Clapet coupe-feu_400_300:7839847
In: 01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet coupe-feu_400_300; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570HR 1

# IfcFlowController: Clapet régulateur_125 (55)
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet régulateur_125; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Valve_Round Standard_MEPcontent_Gaine d'Air Générique_Control valve:Clapet régulateur_125:...) | In | Group
7809592 | 01 | M570HR 1
7809601 | 01 | M570HR 1
7809606 | 01 | M570HR 1
7809640 | 01 | M570HR 1
7809657 | 01 | M570HR 1
7809660 | 01 | M570HR 1
7809678 | 01 | M570HR 1
7810146 | 01 | M570HR 1
7818419 | 01 | M570HR 1
7818432 | 01 | M570HR 1
7818445 | 01 | M570HR 1
7819697 | 01 | M570HR 1
7819856 | 01 | M570HR 1
7819935 | 01 | M570HR 1
7819960 | 01 | M570HR 1
7819980 | 01 | M570HR 1
7819989 | 01 | M570HR 1
7820054 | 01 | M570HR 1
7820071 | 01 | M570HR 1
7820715 | 01 | M570HR 1
7820869 | 01 | M570HR 2
7821114 | 01 | M570HR 2
7821148 | 01 | M570HR 2
7821167 | 01 | M570HR 2
7821184 | 01 | M570HR 2
7821377 | 01 | M570HR 2
7821529 | 01 | M570HR 2
7821893 | S01 | M570HR 1
7821917 | S01 | M570HR 1
7821951 | S01 | M570HR 1
7822003 | S01 | M570HR 1
7822684 | S01 | M570HR 1
7822689 | S01 | M570HR 1
7822920 | S01 | M570HR 1
7822955 | S01 | M570HR 1
7822972 | S01 | M570HR 1
7824673 | S01 | M570HR 2
7824746 | S01 | M570HR 2
7830262 | S02 | M570HR 1
7830271 | S02 | M570HR 1
7830285 | S02 | M570HR 1
7830687 | S02 | M570HR 1
7831016 | S02 | M570HR 1
7831337 | S02 | M570HR 1
7831367 | S02 | M570HR 1
7831441 | S02 | M570HR 1
7833070 | S02 | M570HR 1
7833092 | S02 | M570HR 1
7833880 | S02 | M570HR 1
7841032 | S02 | M570HR 2
7841385 | S02 | M570HR 2
7841408 | S02 | M570HR 2
7841439 | S02 | M570HR 2
7841502 | S02 | M570HR 2
8519243 | 01 | M570HR 1

# IfcFlowController: Clapet régulateur_160 (7)
In: S01
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Clapet régulateur_160; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Valve_Round Standard_MEPcontent_Gaine d'Air Générique_Control valve:Clapet régulateur_160:...) | Group
7822829 | M570HR 1
7824805 | M570HR 2
7824813 | M570HR 2
7824840 | M570HR 2
7824848 | M570HR 2
7824871 | M570HR 2
7824879 | M570HR 2

# IfcFlowController: VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_EX (39)
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_EX; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_EX:VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_EX:...) | In | Group
7812994 | 01 | M570HR 1
7819377 | 01 | M570HR 1
7820971 | 01 | M570HR 2
7831844 | S02 | M570HR 1
7832521 | S02 | M570HR 1
7832880 | S02 | M570HR 1
7833522 | S02 | M570HR 1
7840579 | S02 | M570HR 2
8837291 | S02 | M570HR 2
8846805 | 01 | M570HR 1
8847567 | 01 | M570HR 1
8847665 | 01 | M570HR 1
8847732 | 01 | M570HR 1
8847920 | 01 | M570HR 1
8848233 | 01 | M570HR 1
8848258 | 01 | M570HR 1
8848275 | 01 | M570HR 1
8848602 | 01 | M570HR 1
8848609 | 01 | M570HR 1
8848659 | 01 | M570HR 1
8848678 | 01 | M570HR 1
8849242 | 01 | M570HR 2
8849297 | 01 | M570HR 2
8849514 | 01 | M570HR 2
8849526 | 01 | M570HR 2
8849782 | S01 | M570HR 1
8849789 | S01 | M570HR 1
8850111 | S01 | M570HR 1
8850117 | S01 | M570HR 1
8850137 | S01 | M570HR 1
8850151 | S01 | M570HR 1
8850828 | S01 | M570HR 2
8850839 | S01 | M570HR 2
8851138 | S01 | M570HR 2
8851373 | S01 | M570HR 2
8851385 | S01 | M570HR 2
8851397 | S01 | M570HR 2
8851436 | S01 | M570HR 2
8851453 | S01 | M570HR 2

# IfcFlowFitting: 45 Graden (23)
Pset_DistributionFlowElementCommon - Reference: 45 Graden; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Name | In | Group
Circulaire - Raccord réducteur_Rechth:45 Graden:7831259 | S02 | M570HR 1
Rechth - Raccord réducteur_Circulaire:45 Graden:7832496 | S02 | M570HR 1
Circulaire - Raccord réducteur_Rechth:45 Graden:7841316 | S02 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:7860342 | S02 | M570HR 2
Rechth - Raccord réducteur_Circulaire:45 Graden:7877333 | S02 | M570HR 1
Rechth - Raccord réducteur_Circulaire:45 Graden:8413944 | S01 | M570HR 1
Circulaire - Raccord réducteur_Rechth:45 Graden:8414545 | S01 | M570HR 1
Circulaire - Raccord réducteur_Rechth:45 Graden:8417053 | S01 | M570HR 1
Circulaire - Raccord réducteur_Rechth:45 Graden:8418565 | S01 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8419065 | S01 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8419155 | S01 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8419317 | S01 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8421573 | S01 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8421704 | S01 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8572500 | S02 | M570HR 4
Circulaire - Raccord réducteur_Rechth:45 Graden:8833528 | 01 | M570HR 2
Rechth - Raccord réducteur_Circulaire:45 Graden:8835426 | S02 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8835701 | S02 | M570HR 3
Circulaire - Raccord réducteur_Rechth:45 Graden:8837515 | S02 | M570HR 2
Circulaire - Raccord réducteur_Rechth:45 Graden:8850624 | S01 | M570HR 1
Circulaire - Raccord réducteur_Rechth:45 Graden:8895214 | 01 | M570HR 1
Circulaire - Raccord réducteur_Rechth:45 Graden:8895741 | 01 | M570HR 1
Rechth - Raccord réducteur_Circulaire:45 Graden:8895771 | 01 | M570HR 1

# IfcFlowFitting: Gaine d'Air Générique, 15°, 200-200 (2)
In: 03_R+2_EL
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique, 15°, 200-200; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570HR 1
Name (VE_Bend_Round_AI_MEPcontent:Gaine d'Air Générique, 15°, 200-200:...)
7818319
7818321

# IfcFlowFitting: Gaine d'Air Générique, 90°, 125-125, VE_Bend_Round_AI_MEPcontent:Gaine d'Air Générique, 90°, 125-125:7833430
In: S02
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique, 90°, 125-125; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570HR 1

# IfcFlowFitting: Gaine d'Air Générique, Excentrique, 160-125, offset h(0), offset w(17,5), VE_Reducer_Round_AI_MEPcontent:Gaine d'Air Générique, Excentrique, 160-125, offset h(0), offset w(17,5):8408824
In: 01
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique, Excentrique, 160-125, offset h(0), offset w(17,5); sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570HR 1

# IfcFlowFitting: Gaine d'Air Générique, Excentrique, 200-160, offset h(0), offset w(20), VE_Reducer_Round_AI_MEPcontent:Gaine d'Air Générique, Excentrique, 200-160, offset h(0), offset w(20):8408494
In: 01
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique, Excentrique, 200-160, offset h(0), offset w(20); sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570HR 1

# IfcFlowFitting: Gaine d'Air Générique, Excentrique, 250-125, offset h(0), offset w(62,5), VE_Reducer_Round_AI_MEPcontent:Gaine d'Air Générique, Excentrique, 250-125, offset h(0), offset w(62,5):8416991
In: S01
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique, Excentrique, 250-125, offset h(0), offset w(62,5); sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570HR 1

# IfcFlowFitting: M_Bend_Circular_MEPcontent_Cuivre_2M (431)
Type - PredefinedType: BEND
Pset_DistributionFlowElementCommon - Reference: M_Bend_Circular_MEPcontent_Cuivre_2M; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (M_Bend_Circular_MEPcontent_Cuivre_2M:M_Bend_Circular_MEPcontent_Cuivre_2M:...) | In | Group
7902721 | 01 | M5448FF 2
7902725 | 01 | M5448FF 2
7902729 | 01 | M5448FF 1
7902733 | 01 | M5448FF 1
7902737 | 01 | M5448FF 1
7906632 | 01 | M5448FF 1
7906635 | 01 | M5448FF 1
7906675 | 01 | M5448FF 2
7906678 | 01 | M5448FF 2
7908115 | 01 | M5448FF 2
7908122 | 01 | M5448FF 2
7908125 | 01 | M5448FF 2
7908218 | 01 | M5448FF 1
7908222 | 01 | M5448FF 1
7908225 | 01 | M5448FF 1
7908260 | 01 | M5448FF 1
7908263 | 01 | M5448FF 1
7908307 | 01 | M5448FF 2
7908310 | 01 | M5448FF 2
7908938 | 01 | M5448FF 1
7908976 | 01 | M5448FF 2
7908991 | 01 | M5448FF 1
7908995 | 01 | M5448FF 1
7909001 | 01 | M5448FF 2
7909005 | 01 | M5448FF 2
7911265 | 01 | M5448FF 1
7911293 | 01 | M5448FF 2
7913179 | 01 | M5448FF 1
7913183 | 01 | M5448FF 1
7913215 | 01 | M5448FF 2
7913219 | 01 | M5448FF 2
7913347 | 01 | M5448FF 1
7913380 | 01 | M5448FF 2
7913862 | 01 | M5448FF 1
7913870 | 01 | M5448FF 1
7913931 | 01 | M5448FF 2
7913954 | 01 | M5448FF 1
7914027 | 01 | M5448FF 2
7914035 | 01 | M5448FF 2
7914219 | 01 | M5448FF 1
7914232 | 01 | M5448FF 1
7914287 | 01 | M5448FF 2
7914295 | 01 | M5448FF 2
7914817 | 01 | M5448FF 1
7914820 | 01 | M5448FF 1
7914858 | 01 | M5448FF 2
7914861 | 01 | M5448FF 2
7914896 | 01 | M5448FF 1
7914908 | 01 | M5448FF 2
7915096 | 01 | M5448FF 1
7915099 | 01 | M5448FF 1
7915135 | 01 | M5448FF 2
7915138 | 01 | M5448FF 2
7915486 | 01 | M5448FF 1
7915489 | 01 | M5448FF 1
7915521 | 01 | M5448FF 2
7915524 | 01 | M5448FF 2
7915573 | 01 | M5448FF 1
7915580 | 01 | M5448FF 2
7915620 | 01 | M5448FF 1
7915627 | 01 | M5448FF 2
7915663 | 01 | M5448FF 1
7915670 | 01 | M5448FF 2
7915824 | 01 | M5448FF 1
7915827 | 01 | M5448FF 1
7915865 | 01 | M5448FF 2
7915868 | 01 | M5448FF 2
7915901 | 01 | M5448FF 2
7915904 | 01 | M5448FF 2
7915937 | 01 | M5448FF 1
7915940 | 01 | M5448FF 1
7915975 | 01 | M5448FF 2
7915978 | 01 | M5448FF 2
7916011 | 01 | M5448FF 1
7916014 | 01 | M5448FF 1
7916047 | 01 | M5448FF 2
7916050 | 01 | M5448FF 2
7916083 | 01 | M5448FF 1
7916086 | 01 | M5448FF 1
7916132 | 01 | M5448FF 1
7916135 | 01 | M5448FF 1
7916168 | 01 | M5448FF 2
7916171 | 01 | M5448FF 2
8073122 | 01 | M5448FF 5
8073129 | 01 | M5448FF 6
8073174 | 01 | M5448FF 5
8073181 | 01 | M5448FF 6
8073234 | 01 | M5448FF 5
8073241 | 01 | M5448FF 6
8073288 | 01 | M5448FF 5
8073295 | 01 | M5448FF 6
8073733 | 01 | M5448FF 6
8075083 | 01 | M5448FF 6
8075141 | 01 | M5448FF 6
8075278 | 01 | M5448FF 6
8075330 | 01 | M5448FF 5
8075352 | 01 | M5448FF 6
8076536 | 01 | M5448FF 5
8076540 | 01 | M5448FF 5
8076576 | 01 | M5448FF 6
8076580 | 01 | M5448FF 6
8078843 | 01 | M5448FF 6
8078846 | 01 | M5448FF 6
8078885 | 01 | M5448FF 5
8078888 | 01 | M5448FF 5
8078934 | 01 | M5448FF 6
8078972 | 01 | M5448FF 5
8078975 | 01 | M5448FF 5
8079435 | 01 | M5448FF 5
8079481 | 01 | M5448FF 6
8079489 | 01 | M5448FF 6
8079537 | 01 | M5448FF 6
8079591 | 01 | M5448FF 5
8079630 | 01 | M5448FF 6
8079638 | 01 | M5448FF 6
8079724 | 01 | M5448FF 6
8079821 | 01 | M5448FF 5
8079860 | 01 | M5448FF 6
8079873 | 01 | M5448FF 6
8079911 | 01 | M5448FF 6
8080032 | 01 | M5448FF 5
8080073 | 01 | M5448FF 6
8080081 | 01 | M5448FF 6
8080123 | 01 | M5448FF 6
8080302 | 01 | M5448FF 6
8080335 | 01 | M5448FF 5
8270480 | S01 | M5448FF 5
8270487 | S01 | M5448FF 5
8270494 | S01 | M5448FF 5
8270501 | S01 | M5448FF 5
8270527 | S01 | M5448FF 5
8270548 | S01 | M5448FF 5
8270552 | S01 | M5448FF 5
8270562 | S01 | M5448FF 5
8270565 | S01 | M5448FF 5
8270575 | S01 | M5448FF 5
8270578 | S01 | M5448FF 5
8270583 | S01 | M5448FF 5
8270593 | S01 | M5448FF 5
8270602 | S01 | M5448FF 5
8270613 | S01 | M5448FF 5
8270629 | S01 | M5448FF 6
8270636 | S01 | M5448FF 6
8270643 | S01 | M5448FF 6
8270650 | S01 | M5448FF 6
8270664 | S01 | M5448FF 6
8270668 | S01 | M5448FF 6
8270672 | S01 | M5448FF 6
8270680 | S01 | M5448FF 6
8270684 | S01 | M5448FF 6
8270709 | S01 | M5448FF 6
8270713 | S01 | M5448FF 6
8270723 | S01 | M5448FF 6
8270726 | S01 | M5448FF 6
8270736 | S01 | M5448FF 6
8270739 | S01 | M5448FF 6
8270744 | S01 | M5448FF 6
8270748 | S01 | M5448FF 6
8270754 | S01 | M5448FF 6
8270769 | S01 | M5448FF 6
8270773 | S01 | M5448FF 6
8270779 | S01 | M5448FF 6
8270795 | S01 | M5448FF 6
8270799 | S01 | M5448FF 6
8270803 | S01 | M5448FF 6
8270819 | S01 | M5448FF 6
8270823 | S01 | M5448FF 6
8270829 | S01 | M5448FF 6
8270877 | S01 | M5448FF 6
8270880 | S01 | M5448FF 6
8270892 | S01 | M5448FF 5
8270895 | S01 | M5448FF 5
8273861 | S01 | M5448FF 10
8273865 | S01 | M5448FF 9
8273887 | S01 | M5448FF 9
8273891 | S01 | M5448FF 9
8273900 | S01 | M5448FF 10
8273904 | S01 | M5448FF 10
8273932 | S01 | M5448FF 9
8273935 | S01 | M5448FF 9
8273957 | S01 | M5448FF 9
8273964 | S01 | M5448FF 10
8274028 | S01 | M5448FF 9
8274031 | S01 | M5448FF 9
8274043 | S01 | M5448FF 10
8274046 | S01 | M5448FF 10
8274053 | S01 | M5448FF 9
8274060 | S01 | M5448FF 10
8274077 | S01 | M5448FF 9
8274084 | S01 | M5448FF 10
8274184 | S01 | M5448FF 10
8274187 | S01 | M5448FF 10
8274199 | S01 | M5448FF 9
8274202 | S01 | M5448FF 9
8274214 | S01 | M5448FF 10
8274217 | S01 | M5448FF 10
8274229 | S01 | M5448FF 9
8274232 | S01 | M5448FF 9
8274274 | S01 | M5448FF 9
8274277 | S01 | M5448FF 9
8274289 | S01 | M5448FF 10
8274292 | S01 | M5448FF 10
8274517 | S01 | M5448FF 10
8274563 | S01 | M5448FF 9
8274566 | S01 | M5448FF 9
8274601 | S01 | M5448FF 10
8274604 | S01 | M5448FF 10
8274640 | S01 | M5448FF 9
8274643 | S01 | M5448FF 9
8276045 | S01 | M5448FF 9
8276065 | S01 | M5448FF 9
8276101 | S01 | M5448FF 10
8276109 | S01 | M5448FF 10
8276248 | S01 | M5448FF 9
8276277 | S01 | M5448FF 10
8276577 | 01 | M5448FF 2
8276592 | 01 | M5448FF 1
8277096 | 01 | M5448FF 6
8277703 | S02 | M5448FF 10
8277709 | S02 | M5448FF 9
8277730 | S02 | M5448FF 10
8277739 | S02 | M5448FF 9
8277777 | S02 | M5448FF 10
8277791 | S02 | M5448FF 9
8277905 | S02 | M5448FF 9
8277944 | S02 | M5448FF 10
8277980 | S02 | M5448FF 9
8278012 | S02 | M5448FF 10
8278060 | S02 | M5448FF 9
8281824 | S02 | M5448FF 10
8281829 | S02 | M5448FF 9
8281833 | S02 | M5448FF 10
8281864 | S02 | M5448FF 9
8281867 | S02 | M5448FF 9
8281879 | S02 | M5448FF 10
8281882 | S02 | M5448FF 10
8318883 | S02 | M5448FF 1
8318887 | S02 | M5448FF 2
8321296 | S02 | M5448FF 6
8321307 | S02 | M5448FF 2
8321314 | S02 | M5448FF 1
8321328 | S02 | M5448FF 2
8321332 | S02 | M5448FF 1
8321381 | S02 | M5448FF 5
8358742 | S02 | M531 3
8358832 | S02 | M531 3
8359022 | S02 | M531 3
8359962 | S02 | M531 3
8359988 | S02 | M531 3
8360076 | S02 | M531 3
8382444 | S02 | M531 3
8382455 | S02 | M531 3
8384128 | S02 | M531 3
8384136 | S01 | M531 3
8384793 | S01 | M531 3
8384921 | S01 | M531 3
8384968 | S01 | M531 3
8385204 | S01 | M532F 3
8385422 | S01 | M532F 3
8385452 | S01 | M532F 3
8385515 | S01 | M532F 3
8386688 | S01 | M531 3
8387220 | S01 | M532F 4
8391269 | 01 | M531 3
8391469 | 01 | M531 3
8391766 | 01 | M531 3
8391870 | 01 | M531 3
8393664 | 01 | M532F 5
8394718 | 01 | M532F 5
8394853 | 01 | M531 3
8394877 | 01 | M531 3
8394918 | 01 | M532F 5
8394939 | 01 | M531 3
8403028 | 01 | M5448FF 6
8403072 | 01 | M5448FF 5
8403130 | 01 | M5448FF 6
8403133 | 01 | M5448FF 6
8403156 | 01 | M5448FF 5
8403366 | S01 | M5448FF 6
8403570 | S01 | M5448FF 5
8444510 | S02 | M531 3
8445744 | S02 | M531 3
8446483 | S02 | M531 3
8454563 | 01 | M5448FF 15
8454576 | 01 | M5448FF 15
8454716 | 01 | M5448FF 16
8454724 | 01 | M5448FF 16
8454892 | 01 | M5448FF 15
8454929 | 01 | M5448FF 16
8455014 | 01 | M5448FF 15
8455043 | S02 | M5448FF 15
8455069 | 01 | M5448FF 16
8455079 | S02 | M5448FF 16
8455329 | S02 | M5448FF 16
8455377 | S02 | M5448FF 15
8455566 | S02 | M5448FF 16
8455596 | S02 | M5448FF 16
8455613 | S02 | M5448FF 16
8455624 | S02 | M5448FF 16
8455653 | S02 | M5448FF 15
8455668 | S02 | M5448FF 15
8455693 | S02 | M5448FF 15
8455703 | S02 | M5448FF 15
8456156 | S02 | M5448FF 16
8456166 | S02 | M5448FF 16
8456202 | S02 | M5448FF 15
8456214 | S02 | M5448FF 15
8466473 | S01 | M5448FF 6
8466512 | S01 | M5448FF 5
8467403 | 01 | M531 3
8468094 | 01 | M531 3
8468667 | 01 | M5448FF 1
8468694 | 01 | M5448FF 1
8468722 | 01 | M5448FF 2
8468743 | 01 | M5448FF 2
8468927 | 01 | M5448FF 1
8468930 | 01 | M5448FF 1
8468971 | 01 | M5448FF 1
8468974 | 01 | M5448FF 1
8469007 | 01 | M5448FF 2
8469010 | 01 | M5448FF 2
8469047 | 01 | M5448FF 2
8469050 | 01 | M5448FF 2
8469159 | S02 | M5448FF 2
8469181 | S02 | M5448FF 1
8469184 | S01 | M5448FF 1
8469605 | S02 | M5448FF 2
8469658 | S02 | M5448FF 16
8469703 | S02 | M5448FF 15
8469916 | S01 | M5448FF 10
8469924 | S01 | M5448FF 10
8469972 | S01 | M5448FF 10
8470025 | S01 | M5448FF 9
8470033 | S01 | M5448FF 9
8470051 | S01 | M5448FF 9
8470263 | S02 | M5448FF 9
8470298 | S02 | M5448FF 10
8470383 | S02 | M5448FF 9
8470391 | S02 | M5448FF 9
8470401 | S02 | M5448FF 9
8470424 | S02 | M5448FF 10
8470432 | S02 | M5448FF 10
8470442 | S02 | M5448FF 10
8470861 | 01 | M5448FF 2
8470894 | 01 | M5448FF 1
8470948 | 01 | M5448FF 2
8470982 | 01 | M5448FF 1
8471130 | S02 | M5448FF 13
8471164 | S02 | M5448FF 14
8471263 | S02 | M5448FF 15
8471284 | S02 | M5448FF 16
8471349 | S02 | M5448FF 16
8471377 | S02 | M5448FF 15
8471875 | S02 | M5448FF 13
8471902 | S02 | M5448FF 13
8472200 | S02 | M5448FF 14
8472214 | S02 | M5448FF 14
8472701 | S02 | M5448FF 13
8472778 | S02 | M5448FF 14
8472801 | S02 | M5448FF 13
8472811 | S02 | M5448FF 13
8472832 | S02 | M5448FF 14
8472842 | S02 | M5448FF 14
8473423 | S02 | M531 3
8473425 | S02 | M531 3
8474600 | S02 | M531 3
8474716 | S02 | M531 3
8474773 | S02 | M531 3
8474783 | S02 | M531 3
8474906 | S02 | M532F 6
8474916 | S02 | M532F 6
8474924 | S02 | M532F 6
8478649 | 01 | M531 3
8478911 | 01 | M531 3
8478913 | 01 | M531 3
8479136 | 01 | M531 3
8479138 | 01 | M531 3
8479218 | 01 | M531 3
8479764 | 01 | M531 3
8479790 | 01 | M531 3
8479792 | 01 | M531 3
8479968 | 01 | M531 3
8480041 | 01 | M531 3
8480132 | 01 | M531 3
8480168 | 01 | M531 3
8480477 | 01 | M531 3
8480636 | 01 | M531 3
8480748 | 01 | M531 3
8481067 | 01 | M531 3
8481127 | 01 | M531 3
8481182 | 01 | M531 3
8481184 | 01 | M531 3
8481473 | 01 | M531 3
8481797 | 01 | M531 3
8481825 | 01 | M531 3
8482013 | S01 | M531 3
8482035 | S01 | M531 3
8482105 | S01 | M531 3
8482107 | S01 | M531 3
8482147 | S01 | M531 3
8482170 | S01 | M531 3
8482172 | S02 | M531 3
8482222 | S01 | M531 3
8482809 | S01 | M531 3
8482904 | S01 | M531 3
8483353 | S01 | M531 3
8483379 | S01 | M531 3
8483759 | S01 | M532F 4
8483866 | S01 | M532F 4
8483892 | S01 | M532F 4
8483926 | S01 | M531 3
8498206 | S01 | M5448FF 10
8498218 | S01 | M5448FF 9
8498239 | S01 | M5448FF 10
8498287 | S01 | M5448FF 9
8498455 | S01 | M5448FF 9
8498498 | S01 | M5448FF 10
8696829 | S02 | M531 3
8696985 | S02 | M531 3
8836975 | S02 | M5448FF 13
8836978 | S02 | M5448FF 13
8836999 | S02 | M5448FF 14
8837002 | S02 | M5448FF 14
8864279 | 01 | M5448FF 5
8864283 | 01 | M5448FF 5
8864326 | S01 | M5448FF 5
8864366 | 01 | M5448FF 5
8864370 | S02 | M5448FF 5
8890898 | S01 | M5448FF 10
8890909 | S01 | M5448FF 10
8890913 | S01 | M5448FF 10

# IfcFlowFitting: M_End Piece Cover_Circular Rounded_MEPcontent_Cuivre_1M (2)
In: S02
Pset_DistributionFlowElementCommon - Reference: M_End Piece Cover_Circular Rounded_MEPcontent_Cuivre_1M; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (M_End Piece Cover_Circular Rounded_MEPcontent_Cuivre_1M:M_End Piece Cover_Circular Rounded_MEPcontent_Cuivre_1M:...) | Group
8474564 | M531 3
8474995 | M532F 6

# IfcFlowFitting: M_Reducer_Circular_MEPcontent_Cuivre_2M (5)
Type - PredefinedType: TRANSITION
Pset_DistributionFlowElementCommon - Reference: M_Reducer_Circular_MEPcontent_Cuivre_2M; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Group: M531 3
Name (M_Reducer_Circular_MEPcontent_Cuivre_2M:M_Reducer_Circular_MEPcontent_Cuivre_2M:...) | In
8359477 | S02
8388404 | 01
8388834 | 01
8389262 | 01
8482754 | S01

# IfcFlowFitting: M_Tee_Circular_MEPcontent_Cuivre_3M (118)
Type - PredefinedType: JUNCTION
Pset_DistributionFlowElementCommon - Reference: M_Tee_Circular_MEPcontent_Cuivre_3M; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (M_Tee_Circular_MEPcontent_Cuivre_3M:M_Tee_Circular_MEPcontent_Cuivre_3M:...) | In | Group
7906622 | 01 | M5448FF 1
7906665 | 01 | M5448FF 2
7906715 | 01 | M5448FF 1
7906754 | 01 | M5448FF 2
7908250 | 01 | M5448FF 1
7908297 | 01 | M5448FF 2
7908932 | 01 | M5448FF 1
7908970 | 01 | M5448FF 2
7914807 | 01 | M5448FF 1
7914848 | 01 | M5448FF 2
7915086 | 01 | M5448FF 1
7915125 | 01 | M5448FF 2
7915476 | 01 | M5448FF 1
7915511 | 01 | M5448FF 2
7915814 | 01 | M5448FF 1
7915855 | 01 | M5448FF 2
7915891 | 01 | M5448FF 2
7915927 | 01 | M5448FF 1
7915965 | 01 | M5448FF 2
7916001 | 01 | M5448FF 1
7916037 | 01 | M5448FF 2
7916073 | 01 | M5448FF 1
7916122 | 01 | M5448FF 1
7916158 | 01 | M5448FF 2
8078833 | 01 | M5448FF 6
8078875 | 01 | M5448FF 5
8078962 | 01 | M5448FF 5
8079438 | 01 | M5448FF 5
8079539 | 01 | M5448FF 6
8079594 | 01 | M5448FF 5
8079726 | 01 | M5448FF 6
8079824 | 01 | M5448FF 5
8079913 | 01 | M5448FF 6
8080035 | 01 | M5448FF 5
8080125 | 01 | M5448FF 6
8270557 | S01 | M5448FF 5
8270570 | S01 | M5448FF 5
8270586 | S01 | M5448FF 5
8270596 | S01 | M5448FF 5
8270605 | S01 | M5448FF 5
8270616 | S01 | M5448FF 5
8270718 | S01 | M5448FF 6
8270731 | S01 | M5448FF 6
8270756 | S01 | M5448FF 6
8270781 | S01 | M5448FF 6
8270805 | S01 | M5448FF 6
8270831 | S01 | M5448FF 6
8270870 | S01 | M5448FF 6
8270885 | S01 | M5448FF 5
8273925 | S01 | M5448FF 9
8273940 | S01 | M5448FF 10
8274021 | S01 | M5448FF 9
8274036 | S01 | M5448FF 10
8274177 | S01 | M5448FF 10
8274192 | S01 | M5448FF 9
8274207 | S01 | M5448FF 10
8274222 | S01 | M5448FF 9
8274267 | S01 | M5448FF 9
8274282 | S01 | M5448FF 10
8274553 | S01 | M5448FF 9
8274591 | S01 | M5448FF 10
8274630 | S01 | M5448FF 9
8277899 | S02 | M5448FF 9
8277938 | S02 | M5448FF 10
8277974 | S02 | M5448FF 9
8278006 | S02 | M5448FF 10
8281857 | S02 | M5448FF 9
8281872 | S02 | M5448FF 10
8359955 | S02 | M531 3
8359981 | S02 | M531 3
8360025 | S02 | M531 3
8360072 | S02 | M531 3
8382408 | S02 | M531 3
8384110 | S02 | M531 3
8384955 | S01 | M531 3
8386739 | S01 | M531 3
8386799 | S01 | M531 3
8386904 | S01 | M531 3
8391346 | 01 | M531 3
8391389 | 01 | M531 3
8393585 | 01 | M531 3
8394772 | 01 | M531 3
8444474 | S02 | M531 3
8444500 | S02 | M531 3
8446454 | S02 | M531 3
8466476 | S01 | M5448FF 6
8468917 | 01 | M5448FF 1
8468961 | 01 | M5448FF 1
8468997 | 01 | M5448FF 2
8469037 | 01 | M5448FF 2
8469966 | S01 | M5448FF 10
8470045 | S01 | M5448FF 9
8470950 | 01 | M5448FF 2
8470984 | 01 | M5448FF 1
8473417 | S02 | M531 3
8474718 | S02 | M531 3
8474743 | S02 | M531 3
8474950 | S02 | M532F 6
8474979 | S02 | M532F 6
8475206 | S02 | M531 3
8475229 | S02 | M531 3
8475253 | S02 | M531 3
8479220 | 01 | M531 3
8480170 | 01 | M531 3
8480473 | 01 | M531 3
8480750 | 01 | M531 3
8481069 | 01 | M531 3
8481129 | 01 | M531 3
8481167 | 01 | M531 3
8481448 | S02 | M531 3
8481475 | S02 | M531 3
8482756 | S01 | M531 3
8482811 | S01 | M531 3
8483928 | S01 | M531 3
8498458 | S01 | M5448FF 9
8498501 | S01 | M5448FF 10
8696818 | S02 | M531 3
8864320 | S01 | M5448FF 5

# IfcFlowFitting: PVC (399)
Pset_DistributionFlowElementCommon - Reference: PVC; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Fittings
Name | In | Group
SA_Tee_SW_Generic_MEPcontent:PVC:7904486 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:7907321 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:7907325 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:7907846 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:7908495 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7908498 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7909742 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7909745 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7910263 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7910265 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7910911 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7911014 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:7911018 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7911228 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:7911233 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7911373 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:7911375 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8068178 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068185 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8068202 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068209 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068213 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068216 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8068224 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068231 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068235 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8068237 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8072069 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072071 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072106 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072108 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072133 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072135 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072182 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072264 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072329 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072345 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8072719 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8072723 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8073001 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8073005 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8073200 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8073202 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8073601 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8073603 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8073857 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8073879 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8074515 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8074519 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8075012 | 01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8075017 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8075045 | 01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8075050 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8081218 | 01 | M5232 22
SA_Reducer_SW_Generic_MEPcontent:PVC:8081238 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270349 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270351 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270359 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270361 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270365 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270367 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270369 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270371 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270379 | S01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8270381 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270383 | S01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8270385 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270395 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270397 | S01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8270404 | S01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8270406 | S01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8270465 | S01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8271517 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8271533 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271603 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271605 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271613 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271615 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271633 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271637 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271645 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8271647 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271784 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8271786 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8272639 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8275036 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8275040 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278182 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278192 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278525 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278530 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278593 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278601 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278787 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8278791 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278848 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8278856 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8279004 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8279008 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8279154 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8279193 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8281803 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8321398 | S02 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8321400 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8334392 | 01 | M524 1
SA_Bend_SW_Generic_MEPcontent:PVC:8334507 | 01 | M524 1
SA_Tee_SW_Generic_MEPcontent:PVC:8334511 | 01 | M524 1
SA_Tee_SW_Generic_MEPcontent:PVC:8334878 | 01 | M524 1
SA_Bend_SW_Generic_MEPcontent:PVC:8334885 | 01 | M5232 15
SA_Reducer_SW_Generic_MEPcontent:PVC:8334895 | 01 | M524 1
SA_Bend_SW_Generic_MEPcontent:PVC:8335597 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8335679 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8335776 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8335996 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8336000 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8336125 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8336425 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8336429 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8337295 | S01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8337546 | S01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8337567 | S01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8337636 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8337651 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8337827 | S01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8337972 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8338023 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8338152 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8338334 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8338760 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8338764 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8339125 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8339129 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8340402 | S02 | M524 16
SA_Bend_SW_Generic_MEPcontent:PVC:8340460 | S02 | M524 16
SA_Bend_SW_Generic_MEPcontent:PVC:8340478 | S02 | M524 16
SA_Bend_SW_Generic_MEPcontent:PVC:8340536 | S02 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8340563 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8343810 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8343963 | S02 | M5232 22
SA_Reducer_SW_Generic_MEPcontent:PVC:8344009 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8344593 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8344634 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8344796 | S02 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8344800 | S02 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8344828 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8344864 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8345105 | 01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8345110 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8345166 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8345407 | S02 | M5232 22
