Properties of the parts of a building model (IFC2X3), part 6 of 7

# IfcFlowSegment: Pipe Types:Cuivre_Tuyau (731)
Name (Pipe Types:Cuivre_Tuyau:...) | In | Pset_ElementShading, Color = Pset_FlowSegmentDuctSegment, Color = Pset_FlowSegmentPipeSegment, Color | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
8403324 | S01 | Nouvelle construction | 0.766 | 3.896 | M5448FF 6
8403328 | S01 | Nouvelle construction | 0.406 | 3.896 | M5448FF 6
8403532 | S01 | Nouvelle construction | 0.754 | 3.8935 | M5448FF 5
8403536 | S01 | Nouvelle construction | 0.389 | 3.8935 | M5448FF 5
8443972 | S02 | Nouvelle construction | 0.143786 | -0.455325 | M531 3
8444486 | S02 | Nouvelle construction | 0.253 | -0.455325 | M531 3
8444504 | S02 | Nouvelle construction | 0.134786 | -0.455325 | M531 3
8445589 | S02 | Nouvelle construction | 1.72149 | -0.525325 | M531 3
8445721 | S02 | Nouvelle construction | 3.06517 | -3.602 | M531 3
8445733 | S02 | Nouvelle construction | 0.214187 | -3.6265 | M531 3
8446444 | S02 | Nouvelle construction | 1.5395 | -0.455325 | M531 3
8446473 | S02 | Nouvelle construction | 3.042 | -3.50883 | M531 3
8454123 | 01 | Nouvelle construction | 0.228 | 6.716 | M5448FF 15
8454553 | 01 | Nouvelle construction | 0.751 | 6.716 | M5448FF 15
8454566 | 01 | Nouvelle construction | 0.436 | 6.716 | M5448FF 15
8454691 | 01 | Nouvelle construction | 0.302 | 6.7135 | M5448FF 16
8454703 | 01 | Nouvelle construction | 0.75025 | 6.7135 | M5448FF 16
8454718 | 01 | Nouvelle construction | 0.344 | 6.7135 | M5448FF 16
8454882 | 01 | Nouvelle construction | 7.036 | -0.328 | M5448FF 15
8454917 | 01 | Nouvelle construction | 7.024 | -0.322 | M5448FF 16
8455016 | S02 | Nouvelle construction | 0.310521 | -0.344 | M5448FF 15
8455035 | S02 | Nouvelle construction | 4.4197 | -0.344 | M5448FF 15
8455061 | S02 | Nouvelle construction | 0.218521 | -0.3465 | M5448FF 16
8455071 | S02 | Nouvelle construction | 4.25895 | -0.3465 | M5448FF 16
8455315 | S02 | Nouvelle construction | 10.959 | -0.3465 | M5448FF 16
8455365 | S02 | Nouvelle construction | 11.131 | -0.344 | M5448FF 15
8455554 | S02 | Nouvelle construction | 0.064 | -0.422 | M5448FF 16
8455568 | S02 | Nouvelle construction | 0.396 | -0.4465 | M5448FF 16
8455598 | S02 | Nouvelle construction | 0.129421 | -0.440354 | M5448FF 16
8455618 | S02 | Nouvelle construction | 4.526 | -0.3465 | M5448FF 16
8455641 | S02 | Nouvelle construction | 0.076 | -0.428 | M5448FF 15
8455655 | S02 | Nouvelle construction | 0.484 | -0.444 | M5448FF 15
8455670 | S02 | Nouvelle construction | 0.133421 | -0.44 | M5448FF 15
8455695 | S02 | Nouvelle construction | 4.614 | -0.344 | M5448FF 15
8456146 | S02 | Nouvelle construction | 1.45525 | -0.3465 | M5448FF 16
8456158 | S02 | Nouvelle construction | 1.779 | -0.3465 | M5448FF 16
8456194 | S02 | Nouvelle construction | 1.46725 | -0.344 | M5448FF 15
8456204 | S02 | Nouvelle construction | 1.791 | -0.344 | M5448FF 15
8456331 | S02 | Nouvelle construction | 1.32055 | -0.4081 | M5448FF 13
8456356 | S02 | Nouvelle construction | 1.29855 | -0.4106 | M5448FF 14
8466466 | 01 | Nouvelle construction | 4.3026 | -0.4096 | M5448FF 6
8466477 | 01 | Nouvelle construction | 3.3494 | 3.907 | M5448FF 6
8466505 | 01 | Nouvelle construction | 4.2946 | -0.4036 | M5448FF 5
8467231 | 01 | Nouvelle construction | 0.12025 | 7.25704 | M531 3
8467928 | 01 | Nouvelle construction | 0.153967 | 3.60704 | M531 3
8468318 | S02 | Nouvelle construction | 0.0643662 | -0.351855 | M531 3
8468659 | 01 | Nouvelle construction | 0.204 | 10.7935 | M5448FF 1
8468669 | 01 | Nouvelle construction | 0.184 | 10.7935 | M5448FF 1
8468714 | 01 | Nouvelle construction | 0.216 | 10.796 | M5448FF 2
8468724 | 01 | Nouvelle construction | 0.192 | 10.796 | M5448FF 2
8468915 | 01 | Nouvelle construction | 0.183 | 10.608 | M5448FF 1
8468918 | 01 | Nouvelle construction | 0.039474 | 10.7935 | M5448FF 1
8468959 | 01 | Nouvelle construction | 0.458 | 10.333 | M5448FF 1
8468962 | 01 | Nouvelle construction | 0.289763 | 10.7935 | M5448FF 1
8468995 | 01 | Nouvelle construction | 0.245 | 10.548 | M5448FF 2
8468998 | 01 | Nouvelle construction | 0.043474 | 10.796 | M5448FF 2
8469035 | 01 | Nouvelle construction | 0.466 | 10.327 | M5448FF 2
8469038 | 01 | Nouvelle construction | 0.197763 | 10.796 | M5448FF 2
8469652 | S02 | Nouvelle construction | 0.645419 | -0.3465 | M5448FF 16
8469660 | S02 | Nouvelle construction | 2.651 | -3.009 | M5448FF 16
8469697 | S02 | Nouvelle construction | 0.657419 | -0.344 | M5448FF 15
8469705 | S02 | Nouvelle construction | 2.619 | -2.971 | M5448FF 15
8469908 | S01 | Nouvelle construction | 0.092 | -0.420086 | M5448FF 10
8469918 | S01 | Nouvelle construction | 0.388289 | -0.424086 | M5448FF 10
8469956 | S01 | Nouvelle construction | 0.0517107 | -0.408086 | M5448FF 10
8469967 | S02 | Nouvelle construction | 1.81011 | -0.353375 | M5448FF 10
8470017 | S01 | Nouvelle construction | 0.0971421 | -0.426904 | M5448FF 9
8470027 | S01 | Nouvelle construction | 0.303825 | -0.43305 | M5448FF 9
8470035 | S01 | Nouvelle construction | 0.0501751 | -0.40855 | M5448FF 9
8470046 | S02 | Nouvelle construction | 1.98211 | -0.355875 | M5448FF 9
8470253 | S02 | Nouvelle construction | 12.494 | -0.355875 | M5448FF 9
8470288 | S02 | Nouvelle construction | 12.666 | -0.353375 | M5448FF 10
8470373 | S02 | Nouvelle construction | 5.77449 | -0.355875 | M5448FF 9
8470385 | S02 | Nouvelle construction | 2.87775 | -0.355875 | M5448FF 9
8470393 | S02 | Nouvelle construction | 2.70945 | -0.355875 | M5448FF 9
8470416 | S02 | Nouvelle construction | 5.78649 | -0.353375 | M5448FF 10
8470426 | S02 | Nouvelle construction | 2.88975 | -0.353375 | M5448FF 10
8470434 | S02 | Nouvelle construction | 2.79545 | -0.353375 | M5448FF 10
8470853 | 01 | Nouvelle construction | 0.216 | 7.516 | M5448FF 2
8470863 | 01 | Nouvelle construction | 0.29 | 7.516 | M5448FF 2
8470886 | 01 | Nouvelle construction | 0.204 | 7.5135 | M5448FF 1
8470896 | 01 | Nouvelle construction | 0.382 | 7.5135 | M5448FF 1
8470943 | 01 | Nouvelle construction | 7.85037 | -0.337375 | M5448FF 2
8470951 | 01 | Nouvelle construction | 3.261 | 7.527 | M5448FF 2
8470977 | 01 | Nouvelle construction | 7.84237 | -0.331375 | M5448FF 1
8470985 | 01 | Nouvelle construction | 3.253 | 7.529 | M5448FF 1
8471049 | S02 | Nouvelle construction | 7.074 | -0.4106 | M5448FF 14
8471095 | S02 | Nouvelle construction | 7.086 | -0.4081 | M5448FF 13
8471122 | S02 | Nouvelle construction | 1.85709 | -0.4081 | M5448FF 13
8471156 | S02 | Nouvelle construction | 1.92509 | -0.4106 | M5448FF 14
8471339 | S02 | Nouvelle construction | 0.262 | -3.0335 | M5448FF 16
8471367 | S02 | Nouvelle construction | 0.188 | -2.987 | M5448FF 15
8471456 | 01 | Nouvelle construction | 7.5611 | 10.342 | M531 3
8471533 | S02 | Nouvelle construction | 0.447304 | -0.458725 | M531 3
8471894 | S02 | Nouvelle construction | 0.118 | -1.7756 | M5448FF 13
8472204 | S02 | Nouvelle construction | 0.042 | -1.79685 | M5448FF 14
8472693 | S02 | Nouvelle construction | 2.036 | -2.4521 | M5448FF 13
8472770 | S02 | Nouvelle construction | 2.024 | -2.4461 | M5448FF 14
8472793 | S02 | Nouvelle construction | 1.141 | -2.4681 | M5448FF 13
8472803 | S02 | Nouvelle construction | 0.188 | -2.6641 | M5448FF 13
8472824 | S02 | Nouvelle construction | 1.209 | -2.4706 | M5448FF 14
8472834 | S02 | Nouvelle construction | 0.182 | -2.6641 | M5448FF 14
8473415 | S02 | Nouvelle construction | 0.0245 | -0.500825 | M531 3
8473545 | S02 | Nouvelle construction | 0.2115 | -0.458725 | M531 3
8474586 | S02 | Nouvelle construction | 0.0227089 | -4.3924 | M531 3
8474602 | S02 | Nouvelle construction | 0.0589571 | -4.457 | M531 3
8474719 | S02 | Nouvelle construction | 0.042 | -4.4799 | M531 3
8474733 | S02 | Nouvelle construction | 0.394 | -4.457 | M531 3
8474744 | S02 | Nouvelle construction | 0.043 | -4.4799 | M531 3
8474763 | S02 | Nouvelle construction | 0.337381 | -4.0515 | M531 3
8474775 | S02 | Nouvelle construction | 0.052 | -4.115 | M531 3
8474871 | S02 | Nouvelle construction | 0.019 | -4.115 | M532F 6
8474898 | S02 | Nouvelle construction | 0.024 | -4.0845 | M532F 6
8474908 | S02 | Nouvelle construction | 0.364 | -4.46 | M532F 6
8474918 | S02 | Nouvelle construction | 0.0424003 | -4.4845 | M532F 6
8474940 | S02 | Nouvelle construction | 0.086 | -4.573 | M532F 6
8474951 | S02 | Nouvelle construction | 0.0415997 | -4.4845 | M532F 6
8474971 | S02 | Nouvelle construction | 0.086 | -4.573 | M532F 6
8474980 | S02 | Nouvelle construction | 0.062 | -4.4845 | M532F 6
8475198 | S02 | Nouvelle construction | 0.09 | -4.573 | M531 3
8475207 | S02 | Nouvelle construction | 0.043 | -4.4799 | M531 3
8475221 | S02 | Nouvelle construction | 0.09 | -4.573 | M531 3
8475230 | S02 | Nouvelle construction | 0.042 | -4.4799 | M531 3
8475245 | S02 | Nouvelle construction | 0.09 | -4.573 | M531 3
8475254 | S02 | Nouvelle construction | 0.397026 | -4.4799 | M531 3
8479215 | 01 | Nouvelle construction | 0.142023 | 7.25704 | M531 3
8479221 | 01 | Nouvelle construction | 0.843112 | 7.25704 | M531 3
8479279 | 01 | Nouvelle construction | 0.084 | 7.26044 | M531 3
8479756 | 01 | Nouvelle construction | 1.52706 | 7.28494 | M531 3
8479954 | 01 | Nouvelle construction | 0.1 | 8.525 | M531 3
8480033 | 01 | Nouvelle construction | 0.1 | 8.525 | M531 3
8480124 | 01 | Nouvelle construction | 0.1 | 4.965 | M531 3
8480171 | 01 | Nouvelle construction | 0.0705608 | 7.25704 | M531 3
8480455 | 01 | Nouvelle construction | 0.094 | 7.25704 | M531 3
8480474 | 01 | Nouvelle construction | 1.01636 | 7.25704 | M531 3
8480628 | 01 | Nouvelle construction | 0.1 | 4.965 | M531 3
8481070 | 01 | Nouvelle construction | 0.24336 | 3.60704 | M531 3
8481155 | 01 | Nouvelle construction | 0.135561 | 3.49204 | M531 3
8481172 | 01 | Nouvelle construction | 1.34473 | 3.84744 | M531 3
8481597 | 01 | Nouvelle construction | 0.830112 | 3.49204 | M531 3
8481789 | 01 | Nouvelle construction | 0.063 | 3.52794 | M531 3
8482005 | S01 | Nouvelle construction | 0.085 | 0.695 | M531 3
8482027 | S01 | Nouvelle construction | 0.085 | 0.695 | M531 3
8482053 | S01 | Nouvelle construction | 0.085 | 0.695 | M531 3
8482757 | S02 | Nouvelle construction | 0.72548 | -0.351855 | M531 3
8482771 | S01 | Nouvelle construction | 0.806821 | -0.348455 | M531 3
8482806 | S01 | Nouvelle construction | 1.22846 | -0.351855 | M531 3
8482812 | S01 | Nouvelle construction | 0.06 | -0.351855 | M531 3
8482847 | S01 | Nouvelle construction | 0.479 | -0.348455 | M531 3
8482896 | S01 | Nouvelle construction | 2.27604 | 1.509 | M531 3
8483183 | S01 | Nouvelle construction | 0.062 | 1.4935 | M531 3
8483275 | S01 | Nouvelle construction | 0.320306 | 1.4935 | M531 3
8483371 | S01 | Nouvelle construction | 0.0309958 | 3.75405 | M531 3
8483850 | S01 | Nouvelle construction | 0.0347 | 3.79654 | M532F 4
8483858 | S01 | Nouvelle construction | 0.0309958 | 3.75405 | M532F 4
8483886 | S01 | Nouvelle construction | 0.0333306 | 1.4935 | M532F 4
8483929 | S01 | Nouvelle construction | 1.81496 | -0.323955 | M531 3
8497774 | S01 | Nouvelle construction | 0.437 | 3.73413 | M5448FF 9
8497781 | S01 | Nouvelle construction | 0.343 | 3.68262 | M5448FF 10
8498229 | S01 | Nouvelle construction | 0.235999 | 3.68262 | M5448FF 10
8498241 | S01 | Nouvelle construction | 0.42625 | 3.68262 | M5448FF 10
8498277 | S01 | Nouvelle construction | 0.124013 | 3.73413 | M5448FF 9
8498289 | S01 | Nouvelle construction | 0.31825 | 3.73413 | M5448FF 9
8498448 | S01 | Nouvelle construction | 4.063 | -0.331375 | M5448FF 9
8498459 | S01 | Nouvelle construction | 0.183 | 3.74962 | M5448FF 9
8498486 | S01 | Nouvelle construction | 4.017 | -0.337375 | M5448FF 10
8498502 | S01 | Nouvelle construction | 0.245 | 3.69362 | M5448FF 10
8696763 | S02 | Nouvelle construction | 2.798 | -3.25583 | M531 3
8696806 | S02 | Nouvelle construction | 0.213986 | -0.455325 | M531 3
8696819 | S02 | Nouvelle construction | 14.1987 | -0.455325 | M531 3
8696831 | S02 | Nouvelle construction | 0.039 | -3.28033 | M531 3
8696979 | S02 | Nouvelle construction | 0.057 | -3.28033 | M531 3
8864265 | 01 |  | 0.064 | 7.2619 | M5448FF 5
8864308 | S01 |  | 0.073 | 3.8935 | M5448FF 5
8864321 | 01 | Nouvelle construction | 3.3414 | 3.909 | M5448FF 5
8864356 | S02 |  | 0.064 | -0.4281 | M5448FF 5
8882693 | 01 | Nouvelle construction | 1.86388 | 10.7935 | M5448FF 1
8882778 | 01 | Nouvelle construction | 0.0672634 | 10.7935 | M5448FF 1
8882955 | 01 | Nouvelle construction | 1.88153 | 10.796 | M5448FF 2
8883242 | 01 | Nouvelle construction | 0.0107347 | 10.796 | M5448FF 2
8883709 | 01 | Nouvelle construction | 1.18718 | 7.5135 | M5448FF 1
8883929 | 01 | Nouvelle construction | 1.32763 | 7.5135 | M5448FF 1
8884143 | 01 | Nouvelle construction | 1.1581 | 7.5135 | M5448FF 1
8884440 | S01 | Nouvelle construction | 0.237168 | 3.94413 | M5448FF 9
8884627 | S01 | Nouvelle construction | 0.0263879 | 3.94413 | M5448FF 9
8884791 | S01 | Nouvelle construction | 1.8687 | 3.94413 | M5448FF 9
8884940 | S01 | Nouvelle construction | 0.173696 | 3.94663 | M5448FF 10
8885200 | S01 | Nouvelle construction | 0.0819751 | 3.94663
8885332 | S01 | Nouvelle construction | 1.2455 | 3.94663 | M5448FF 10
8885384 | S01 | Nouvelle construction | 1.81187 | 3.94663 | M5448FF 10
8885490 | 01 | Nouvelle construction | 1.27191 | 7.516 | M5448FF 2
8885667 | 01 | Nouvelle construction | 1.46839 | 7.516 | M5448FF 2
8885844 | 01 | Nouvelle construction | 1.11081 | 7.516 | M5448FF 2
8886111 | S01 | Nouvelle construction | 1.59996 | 3.94663 | M5448FF 10
8886922 | S01 | Nouvelle construction | 1.65486 | 3.94413 | M5448FF 9
8887244 | 01 | Nouvelle construction | 1.43588 | 7.2644 | M5448FF 6
8887437 | 01 | Nouvelle construction | 0.874075 | 7.2644 | M5448FF 6
8887812 | 01 | Nouvelle construction | 1.56809 | 7.2644 | M5448FF 6
8887919 | S01 | Nouvelle construction | 0.205431 | 3.896 | M5448FF 6
8888077 | S01 | Nouvelle construction | 0.184499 | 3.896 | M5448FF 6
8888166 | S01 | Nouvelle construction | 0.310398 | 3.896 | M5448FF 6
8888359 | 01 | Nouvelle construction | 1.52184 | 7.2619 | M5448FF 5
8888552 | 01 | Nouvelle construction | 0.970316 | 7.2619 | M5448FF 5
8888704 | 01 | Nouvelle construction | 1.61271 | 7.2619 | M5448FF 5
8888815 | S01 | Nouvelle construction | 0.246572 | 3.8935 | M5448FF 5
8888915 | S01 | Nouvelle construction | 0.293486 | 3.8935 | M5448FF 5
8889155 | S01 | Nouvelle construction | 0.401087 | 3.8935 | M5448FF 5
8890890 | S01 | Nouvelle construction | 0.0603675 | 3.69173 | M5448FF 10

# IfcFlowSegment: Pipe Types:Indéfini PVC_Tube lisse 2m (28)
In: S02
Pset_DistributionFlowElementCommon - Reference: Indéfini PVC_Tube lisse 2m; sets with these values: 2
Pset_ElementShading - Color: Nouvelle construction
Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:Indéfini PVC_Tube lisse 2m:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
8350064 | 3.60417 | -4.084 | M531 3
8350343 | 0.687802 | -0.467025 | M531 3
8357690 | 11.943 | -0.467025 | M531 3
8360017 | 2.049 | -0.467025 | M531 3
8383921 | 0.113 | -0.467025 | M531 3
8384111 | 0.783455 | -0.310955 | M531 3
8387888 | 2.933 | 7.29794 | M531 3
8444411 | 1.28543 | -0.467025 | M531 3
8444475 | 0.326982 | -0.467025 | M531 3
8446361 | 0.792331 | -0.467025 | M531 3
8446455 | 3.53636 | -0.467025 | M531 3
8446588 | 1.75824 | -0.467025 | M531 3
8468406 | 3.588 | 3.64794 | M531 3
8473418 | 0.0657611 | -0.467025 | M531 3
8473605 | 0.925751 | -4.1332 | M531 3
8481449 | 0.0448696 | -0.417825 | M531 3
8481476 | 3.05844 | 0.5275 | M531 3
8630857 | 0.142057 | -4.4582 | M531 10
8630870 | 0.374661 | -4.4582 | M531 10
8630945 | 2.59817 | -4.418 | M531 10
8630959 | 0.489317 | -4.4582 | M531 10
8630963 | 1.648 | -1.80703 | M531 10
8631016 | 2.26917 | -4.089 | M531 10
8631103 | 3.918 | -4.1382 | M531 10
8631117 | 0.638 | -4.789 | M531 10
8631198 | 0.849 | -4.8382 | M531 10
8714054 | 0.104351 | -4.4582 | M531 10
8714183 | 0.0578509 | -4.1332 | M531 3

# IfcFlowSegment: Pipe Types:S4Rx_Generic_PVC (486)
Pset_DistributionFlowElementCommon - Reference: S4Rx_Generic_PVC; sets with these values: 2
Pset_ElementShading - Roughness: 0.00005 m
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:S4Rx_Generic_PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
7903128 | 01 | 0.0276357 | 10.4054 | M5232 15
7903815 | 01 | 0.0832206 | 10.5462 | M5232 15
7904203 | 01 | 0.147095 | 10.5674 | M5232 15
7904473 | 01 | 2.12321 | 10.5348 | M5232 15
7904487 | 01 | 1.96744 | 10.5674 | M5232 15
7904550 | 01 | 0.0857188 | 10.5493 | M5232 5
7904552 | 01 | 0.626433 | 10.3831 | M5232 5
7904568 | 01 | 0.084163 | 10.5464 | M5232 5
7904570 | 01 | 0.50102 | 10.33 | M5232 5
7904626 | 01 | 0.0864153 | 10.5458 | M5232 5
7904628 | 01 | 1.69481 | 10.3472 | M5232 5
7904648 | 01 | 0.0863389 | 10.5457 | M5232 5
7904650 | 01 | 1.10573 | 10.2934 | M5232 5
7907230 | 01 | 0.161888 | 10.6035 | M5232 15
7907285 | 01 | 0.0330749 | 10.5595 | M5232 15
7907317 | 01 | 2.26311 | 10.4914 | M5232 15
7907326 | 01 | 0.539719 | 10.5259 | M5232 15
7907408 | 01 | 0.0892053 | 10.5448 | M5232 15
7907812 | 01 | 2.26622 | 10.6063 | M5232 15
7908493 | 01 | 0.101979 | 10.4356 | M5232 5
7909740 | 01 | 0.118779 | 10.4158 | M5232 5
7909782 | 01 | 0.14786 | 10.3447 | M5232 5
7910261 | 01 | 0.154425 | 10.3807 | M5232 5
7911019 | 01 | 2.50843 | 10.3447 | M5232 5
7911089 | 01 | 0.147315 | 10.3273 | M5232 5
7911224 | 01 | 0.108006 | 10.3248 | M5232 5
7911234 | 01 | 1.11279 | 10.3272 | M5232 5
7911371 | 01 | 0.180933 | 10.3531 | M5232 5
7911513 | 01 | 0.426402 | 10.2862 | M5232 5
8068171 | 01 | 0.0660564 | 7.14614 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068173 | 01 | 0.403673 | 7.19848 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068180 | 01 | 2.86599 | 6.99463 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068192 | 01 | 0.0666155 | 7.26604 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068194 | 01 | 0.279274 | 7.14075 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068196 | 01 | 0.0677348 | 7.26603 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068198 | 01 | 0.279028 | 7.06454 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068200 | 01 | 0.148527 | 7.13807 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068211 | 01 | 0.0666975 | 7.1881 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068220 | 01 | 0.150491 | 7.06187 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068222 | 01 | 1.50858 | 7.03842 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068233 | 01 | 0.142909 | 7.11189 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068240 | 01 | 0.0468002 | 7.14629 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068242 | 01 | 1.90167 | 7.29055 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068248 | 01 | 0.0420231 | 7.26616 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068250 | 01 | 1.91127 | 7.33893 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068256 | 01 | 0.042117 | 7.26643 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8068258 | 01 | 1.91129 | 7.36523 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072063 | 01 | 0.0672356 | 7.26598 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072065 | 01 | 1.13834 | 7.00703 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072067 | 01 | 0.187913 | 7.06716 | M5232 5
8072098 | 01 | 0.0673639 | 7.26603 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072100 | 01 | 0.465357 | 7.06779 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072104 | 01 | 0.136871 | 7.11793 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072125 | 01 | 0.0684521 | 7.26603 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072127 | 01 | 0.338876 | 7.0352 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072131 | 01 | 0.171354 | 7.08345 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8072319 | 01 | 0.176837 | 7.01283 | M5232 5
8072333 | 01 | 0.537897 | 7.00418 | M5232 5
8072349 | 01 | 0.148281 | 7.00158 | M5232 5
8072438 | 01 | 0.149141 | 7.03254 | M5232 5
8072710 | 01 | 1.35339 | 6.98048 | M5232 5
8072724 | 01 | 0.309675 | 7.00158 | M5232 5
8072994 | 01 | 1.06264 | 7.01583 | M5232 5
8073006 | 01 | 2.29422 | 7.03257 | M5232 5
8073142 | 01 | 0.0684522 | 7.14598 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073144 | 01 | 0.44738 | 6.86606 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073146 | 01 | 0.219181 | 6.91578 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073194 | 01 | 0.0684521 | 7.14598 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073196 | 01 | 0.449553 | 6.94353 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073198 | 01 | 0.141316 | 6.99343 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073254 | 01 | 0.068875 | 7.14598 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073256 | 01 | 0.219917 | 6.93028 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073308 | 01 | 0.0681913 | 7.14568 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073310 | 01 | 0.193594 | 6.86289 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073369 | 01 | 0.0707118 | 7.14588 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073371 | 01 | 1.23834 | 6.9605 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073373 | 01 | 0.112763 | 7.02209 | M5232 22
8073413 | 01 | 0.0511397 | 7.14648 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073415 | 01 | 0.409277 | 6.91876 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073453 | 01 | 0.0704134 | 7.14592 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8073849 | 01 | 0.176582 | 6.9575 | M5232 22
8074644 | 01 | 0.147942 | 6.94092 | M5232 22
8074680 | 01 | 0.147645 | 6.8635 | M5232 22
8075008 | 01 | 0.625375 | 6.85332 | M5232 22
8075041 | 01 | 5.10724 | 6.8635 | M5232 22
8075051 | 01 | 1.08377 | 6.94089 | M5232 22
8080655 | 01 | 0.0982965 | 6.95554 | M5232 1
8081210 | 01 | 0.258387 | 6.58392 | M5232 22
8270259 | S01 | 0.0696637 | 3.69598 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270261 | S01 | 0.220315 | 3.56399 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270269 | S01 | 0.0687061 | 3.69597 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270271 | S01 | 0.219262 | 3.50374 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270281 | S01 | 0.0447388 | 3.69642 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270283 | S01 | 0.245179 | 3.58765 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270287 | S01 | 0.0411211 | 3.69623 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270289 | S01 | 0.265174 | 3.60202 | M5232 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270337 | S01 | 0.068763 | 3.69598 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270339 | S01 | 0.447223 | 3.41729 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270341 | S01 | 0.217945 | 3.46702 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270343 | S01 | 0.0681153 | 3.69598 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270345 | S01 | 0.449898 | 3.47112 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270347 | S01 | 0.16371 | 3.52104 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270353 | S01 | 0.0703788 | 3.69588 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270355 | S01 | 1.23747 | 3.50307 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270357 | S01 | 0.12021 | 3.56464 | M5232 22
8270363 | S01 | 0.177378 | 3.50006 | M5232 22
8270373 | S01 | 0.147752 | 3.46851 | M5232 22
8270375 | S01 | 0.14734 | 3.41473 | M5232 22
8270377 | S01 | 0.797496 | 3.40197 | M5232 22
8270386 | S01 | 2.08159 | 3.46849 | M5232 22
8270389 | S01 | 0.0706997 | 3.69588 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270391 | S01 | 1.23901 | 3.44612 | M5232 22 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8270393 | S01 | 0.177143 | 3.50771 | M5232 22
8270399 | S01 | 0.146852 | 3.44355 | M5232 22
8270401 | S01 | 1.86617 | 3.41473 | M5232 22
8270407 | S01 | 1.61185 | 3.44351 | M5232 22
8270466 | 01 | 3.03148 | 3.47243 | M5232 22
8271495 | S01 | 0.0671581 | 3.69601 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271507 | S01 | 0.0641103 | 3.69605 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271511 | S01 | 0.0656078 | 3.69603 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271515 | S01 | 0.146873 | 3.66899 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271518 | S01 | 3.86093 | 3.66897 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271529 | S01 | 0.149068 | 3.58109 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271531 | S01 | 3.58832 | 3.52644 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271534 | S01 | 5.80785 | 3.58106 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271545 | S01 | 0.0381931 | 3.69759 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271547 | S01 | 0.34036 | 3.69185 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271551 | S01 | 0.040105 | 3.69611 | M5232 12 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271553 | S01 | 0.39686 | 3.63503 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271555 | S01 | 0.0417772 | 3.69638 | M5232 8 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271557 | S01 | 0.445483 | 3.54677 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271597 | S01 | 0.0678435 | 3.69599 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271599 | S01 | 0.397181 | 3.45252 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271601 | S01 | 0.183543 | 3.50153 | M5232 5
8271607 | S01 | 0.0672331 | 3.69603 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271609 | S01 | 0.391852 | 3.52644 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271611 | S01 | 0.109311 | 3.57548 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271631 | S01 | 0.297852 | 3.48861 | M5232 5
8271635 | S01 | 1.14633 | 3.47106 | M5232 5
8271639 | S01 | 0.148876 | 3.46846 | M5232 5
8271651 | S01 | 2.14389 | 3.49343 | M5232 5
8271778 | S01 | 0.0681751 | 3.696 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271780 | S01 | 0.431625 | 3.4898 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8271782 | S01 | 0.145741 | 3.53933 | M5232 5
8272625 | S01 | 0.0991203 | 3.48796 | M5232 5
8272664 | S01 | 1.2478 | 3.46845 | M5232 5
8274829 | S01 | 0.148639 | 3.4499 | M5232 5
8275027 | S01 | 1.63301 | 3.42464 | M5232 5
8275041 | S01 | 1.18166 | 3.44993 | M5232 5
8277669 | S02 | 0.0516375 | -1.01348 | M5232 5
8277689 | S02 | 0.0517594 | -1.01348 | M5232 5
8277713 | S02 | 0.05175 | -1.01348 | M5232 5
8277747 | S02 | 0.05175 | -1.01348 | M5232 5
8278120 | S02 | 0.0872416 | -0.836095 | M5232 5
8278169 | S02 | 0.0808143 | -0.83766 | M5232 5
8278474 | S02 | 0.124714 | -0.970484 | M5232 5
8278585 | S02 | 0.0647086 | -0.970484 | M5232 5
8278595 | S02 | 0.0825585 | -0.89603 | M5232 5
8278634 | S02 | 0.0589594 | -0.89726 | M5232 5
8278792 | S02 | 3.95315 | -0.897303 | M5232 5
8278840 | S02 | 0.0440748 | -0.970484 | M5232 5
8278850 | S02 | 0.0724452 | -0.916512 | M5232 5
8278874 | S02 | 0.073437 | -0.918037 | M5232 5
8278997 | S02 | 2.53414 | -0.956958 | M5232 5
8279009 | S02 | 1.337 | -0.918153 | M5232 5
8279146 | S02 | 0.572486 | -0.970485 | M5232 5
8279185 | S02 | 0.620963 | -0.396328 | M5232 5
8281801 | S02 | 0.175069 | -0.959937 | M5232 5
8281805 | S02 | 0.806114 | -0.97238 | M5232 5
8321392 | S02 | 0.394578 | -1.78521 | M5232 22
8321394 | S02 | 0.35633 | -1.79136 | M5232 22
8321396 | 01 | 3.12602 | -4.92315 | M5232 22
8321401 | 01 | 5.11708 | -1.72089 | M5232 22
8321472 | 01 | 0.283233 | 7.95691 | M524 4
8321657 | 01 | 0.0391346 | 8.59098 | M5232 9
8322199 | 01 | 0.137359 | 8.1028 | M524 4
8327323 | 01 | 0.196006 | 7.98788 | M524 4
8327871 | 01 | 0.376786 | 10.8174 | M524 4
8332539 | 01 | 1.10387 | 7.40111 | M5232 5
8332779 | 01 | 0.0742256 | 8.47098 | M5232 10
8332782 | 01 | 1.25166 | 7.13332 | M5232 5
8333657 | 01 | 0.0391346 | 5.03098 | M5232 11
8333660 | 01 | 1.18468 | 3.7603 | M5232 5
8333662 | 01 | 0.0742256 | 4.91098 | M5232 17
8333665 | 01 | 1.02077 | 3.80421 | M5232 5
8333855 | 01 | 0.119963 | 3.70749 | M5232 5
8334264 | 01 | 0.0391346 | 8.50598 | M5232 14
8334267 | 01 | 0.888844 | 7.53114 | M5232 15
8334318 | 01 | 0.205517 | 8.03465 | M524 1
8334377 | 01 | 0.220577 | 7.91926 | M524 1
8334465 | 01 | 0.131353 | 7.9156 | M524 1
8334502 | 01 | 12.7354 | -4.82595 | M524 1
8334512 | 01 | 0.389329 | 10.8049 | M524 1
8334693 | 01 | 0.152926 | 10.4415 | M5232 15
8334866 | 01 | 0.044657 | 10.6032 | M5232 15; M524 1
8334879 | 01 | 2.53029 | 8.02048 | M524 1
8334907 | 01 | 0.332288 | 7.47371 | M5232 15
8334961 | 01 | 0.238872 | 7.51013 | M5232 15
8335514 | 01 | 1.20435 | 7.37505 | M5232 15
8335664 | 01 | 2.27361 | 7.42701 | M5232 15
8335766 | 01 | 0.176725 | 7.37023 | M5232 15
8335780 | 01 | 0.145886 | 7.36628 | M5232 15
8336001 | 01 | 0.0980923 | 7.26207 | M5232 15
8336117 | 01 | 0.0846626 | 7.33132 | M5232 15
8336209 | 01 | 0.108171 | 7.21777 | M5232 15
8336533 | S01 | 0.0391346 | 0.680984 | M5232 6
8336536 | S01 | 0.941144 | -0.34616 | M5232 5
8336570 | S01 | 0.0391346 | 0.760984 | M5232 18
8336573 | S01 | 1.04935 | -0.374362 | M5232 5
8336651 | S01 | 0.948498 | -0.538334 | M524 4
8337025 | S01 | 0.901836 | -0.491672 | M524 4
8337043 | S01 | 0.880188 | -0.470024 | M524 4
8337069 | S01 | 0.280453 | -0.361455 | M5232 5
8337547 | S01 | 0.776668 | -0.596552 | M524 4
8337560 | S01 | 0.521 | -0.655851 | M524 4
8337568 | S01 | 2.22254 | -0.643214 | M524 4
8337626 | S02 | 0.286279 | -0.496695 | M5232 5
8337640 | S02 | 1.05217 | -0.518758 | M5232 5
8337819 | S01 | 4.19848 | -4.86535 | M524 4
8337964 | S02 | 0.114075 | -0.523477 | M5232 5
8338253 | S01 | 0.112031 | -0.427611 | M5232 5
8338357 | S02 | 0.0494301 | -0.429345 | M5232 5
8338751 | S01 | 0.766794 | -0.477094 | M5232 5
8338831 | S02 | 0.16165 | -0.481234 | M5232 5
8339114 | S01 | 0.266639 | -0.489937 | M5232 5
8339130 | S01 | 0.441602 | -0.481284 | M5232 5
8339190 | S02 | 0.0391346 | -3.94402 | M5232 19
8339193 | S02 | 0.476143 | -4.50616 | M5232 5
8339195 | S02 | 0.0742256 | -3.97902 | M5232 24
8339198 | S02 | 0.425 | -4.49002 | M5232 5
8339358 | S02 | 0.630311 | -4.84017 | M524 4
8339511 | S02 | 0.614605 | -4.82446 | M524 4
8339809 | S02 | 0.59812 | -4.80797 | M524 16
8339878 | S02 | 0.164226 | -4.06902 | M5232 25
8339881 | S02 | 0.310963 | -4.46598 | M5232 22
8339945 | S02 | 0.197278 | -4.89828 | M5232 22
8340297 | S02 | 0.153153 | -4.85416 | M5232 22
8340394 | S02 | 2.05425 | -4.96003 | M524 16
8340448 | S02 | 0.14752 | -4.96401 | M524 16
8340482 | S02 | 4.0675 | -5.04614 | M524 16
8340528 | S02 | 0.34869 | -5.07381 | M5232 22
8343788 | S02 | 0.211558 | -4.91256 | M5232 22
8343804 | S02 | 0.577501 | -5.0351 | M5232 22
8343828 | S02 | 0.148103 | -5.03921 | M5232 22
8343995 | S02 | 0.321924 | -4.86791 | M5232 22
8344585 | S02 | 1.35485 | -5.00587 | M5232 22
8344626 | S02 | 0.676272 | -5.02042 | M5232 22
8344801 | S02 | 0.783871 | -5.03942 | M5232 22
8344823 | S02 | 3.02198 | -5.06581 | M5232 22
8344856 | 01 | 1.48444 | -5.06383 | M5232 22
8344893 | S02 | 0.148253 | -5.06804 | M5232 22
8345101 | S02 | 0.108667 | -5.07381 | M5232 22
8345111 | S02 | 1.27908 | -5.06832 | M5232 22
8345146 | S02 | 0.237376 | -4.93838 | M5232 22
8345160 | S02 | 2.46103 | -5.09858 | M5232 22
8345231 | S02 | 0.347815 | -5.10667 | M5232 22
8345412 | S02 | 1.47876 | -5.1067 | M5232 22
8345458 | S02 | 0.174521 | -4.93893 | M524 4
8345492 | S02 | 0.248413 | -4.94493 | M524 4
8345528 | S02 | 0.194532 | -4.95503 | M524 4
8345560 | S02 | 0.120249 | -4.95869 | M524 4
8345700 | S02 | 0.650555 | -4.95892 | M524 4
8345719 | S01 | 0.552206 | -4.98739 | M524 4
8345751 | S02 | 0.149348 | -4.99141 | M524 4
8345884 | S02 | 1.47075 | -4.99165 | M524 4
8345902 | S02 | 0.365609 | -4.95177 | M5232 5
8346380 | S02 | 0.497492 | -5.07271 | M5232 5
8346408 | S02 | 0.249215 | -5.07873 | M5232 5
8346550 | S02 | 0.350722 | -4.92074 | M5232 5
8346690 | S02 | 0.147301 | -5.09556 | M5232 5
8346807 | S02 | 0.794988 | -5.09561 | M5232 5
8346825 | S02 | 0.134853 | -5.09972 | M5232 5
8346864 | S02 | 0.14758 | -5.1037 | M5232 5
8346876 | S02 | 0.602115 | -5.11678 | M5232 5
8346886 | S02 | 0.349258 | -5.12486 | M5232 5
8347026 | S02 | 1.30054 | -5.12494 | M5232 5
8347163 | 01 | 5.32719 | -5.15025 | M5232 22
8347196 | S02 | 0.179227 | -5.1552 | M5232 22
8347655 | S02 | 0.291261 | -5.16433 | M5232 22
8347671 | S02 | 2.26954 | -5.1554 | M5232 22
8347703 | 01 | 8.3585 | -5.10407 | M524 1
8347925 | 01 | 0.700265 | -5.01644 | M524 4
8348013 | S02 | 0.149243 | -5.02071 | M524 4
8348069 | S02 | 0.702335 | -5.1356 | M5232 5
8348084 | S02 | 0.354756 | -5.14386 | M5232 5
8348452 | S02 | 4.00526 | -5.10413 | M524 4
8348464 | S02 | 1.28742 | -5.02072 | M524 4
8348789 | S02 | 3.99856 | -5.22737 | M5232 5
8348799 | S02 | 0.780269 | -5.14386 | M5232 5
8395116 | 01 | 0.139567 | 10.4484 | M5232 15
8395342 | 01 | 0.0605845 | 10.598 | M5232 15
8395829 | 01 | 1.88989 | 10.5702 | M5232 15
8396047 | 01 | 0.04168 | 10.5878 | M5232 15
8396182 | 01 | 0.149431 | 10.4888 | M5232 15
8396257 | 01 | 0.0622534 | 10.4154 | M5232 15
8396368 | 01 | 0.0371325 | 10.3714 | M5232 15
8396638 | 01 | 2.89393 | 7.47116 | M5232 15
8407561 | 01 | 0.175252 | 7.28757 | M5232 15
8407746 | 01 | 0.00442863 | 7.1891 | M5232 15
8408201 | 01 | 0.118966 | 7.18927 | M5232 15
8408316 | 01 | 0.0635713 | 7.21298 | M5232 15
8408382 | 01 | 2.72217 | 7.13805 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8408390 | 01 | 1.21745 | 7.17941 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8409227 | 01 | 0.0473733 | 7.30913 | M5232 15
8409426 | 01 | 0.16164 | 7.33615 | M5232 15
8409466 | 01 | 0.170438 | 7.15469 | M5232 15
8409506 | 01 | 1.07538 | 7.12113 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8409665 | 01 | 0.0734601 | 7.30941 | M5232 15
8409740 | 01 | 0.161641 | 7.36245 | M5232 15
8409775 | 01 | 0.247743 | 7.10369 | M5232 15
8409806 | 01 | 0.516644 | 7.06184 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8409814 | 01 | 3.36504 | 7.07012 | M5232 15 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8410009 | 01 | 0.300298 | 6.98923 | M5232 15
8410021 | 01 | 0.107993 | 6.9868 | M5232 15
8410183 | 01 | 0.0899507 | 7.05727 | M5232 15
8410986 | S01 | 0.252813 | 3.68771 | M5232 5
8411388 | S01 | 0.00409595 | 3.73909 | M5232 12
8411504 | S01 | 0.145515 | 3.63231 | M5232 5
8411796 | S01 | 3.67378 | 3.63226 | M5232 5
8412249 | S01 | 0.00651008 | 3.73936 | M5232 8
8412349 | S01 | 0.0768703 | 3.54521 | M5232 5
8412556 | S01 | 3.75467 | 3.48796 | M5232 5
8412566 | S01 | 5.76 | 3.54507 | M5232 5
8413029 | 01 | 11.8762 | -4.89513 | M5232 15
8421931 | 01 | 1.11788 | 7.51212 | M5232 5
8422081 | 01 | 0.339599 | 7.45432 | M5232 5
8422588 | 01 | 0.24343 | 7.49657 | M5232 5
8422628 | 01 | 0.378708 | 3.81029 | M5232 5
8430116 | 01 | 0.381415 | 7.83829 | M524 4
8432535 | 01 | 0.355961 | 7.97832 | M524 4
8432642 | 01 | 0.356568 | 7.82872 | M524 4
8433006 | 01 | 2.38513 | 8.0832 | M524 4
8433498 | 01 | 0.0385982 | 7.9336 | M524 4
8433630 | 01 | 0.456639 | 10.3171 | M5232 5
8433652 | 01 | 0.32149 | 10.3115 | M5232 5
8433924 | 01 | 0.27053 | 4.39945 | M524 4
8433926 | 01 | 0.157196 | 4.5128 | M524 4
8433928 | 01 | 0.195907 | 4.39789 | M524 4
8433930 | 01 | 0.421499 | 4.28001 | M524 4
8433936 | 01 | 0.355964 | 4.38833 | M524 4
8433938 | 01 | 0.357911 | 4.27042 | M524 4
8433975 | 01 | 9.15574 | -4.89143 | M524 4
8434065 | 01 | 0.0069079 | 4.3753 | M524 4
8434074 | 01 | 3.32939 | 4.49321 | M524 4
8434601 | 01 | 1.49349 | 7.05245 | M5232 5
8434632 | 01 | 0.567868 | 7.37422 | M5232 5
8434821 | 01 | 0.133023 | 7.04855 | M5232 5
8434880 | 01 | 0.2562 | 7.44866 | M5232 5
8434938 | 01 | 0.214285 | 7.3689 | M5232 5
8435067 | 01 | 0.384185 | 7.34251 | M5232 5
8435081 | 01 | 0.155249 | 7.33887 | M5232 5
8435966 | 01 | 0.322437 | 7.11521 | M5232 5
8436013 | 01 | 0.151982 | 7.01392 | M5232 5
8436031 | 01 | 0.253132 | 7.10475 | M5232 5
8436073 | 01 | 0.622075 | 6.99987 | M5232 5
8436089 | 01 | 0.252936 | 7.07491 | M5232 5
8436303 | 01 | 1.12034 | 6.94961 | M5232 5
8436317 | 01 | 1.20157 | 6.97362 | M5232 5
8436532 | S01 | 0.55536 | 3.4155 | M5232 5
8436547 | S01 | 0.0682068 | 3.41367 | M5232 5
8436767 | S01 | 0.756071 | 3.73809 | M5232 5
8436966 | S01 | 0.568449 | 3.63285 | M5232 5
8436994 | S01 | 0.379808 | 3.62282 | M5232 5
8437251 | S01 | 0.0766019 | 3.70574 | M5232 5
8437349 | S01 | 0.865932 | 3.72452 | M5232 5
8437585 | 01 | 0.21248 | 3.69504 | M5232 5
8437798 | 01 | 1.35561 | 3.64666 | M5232 5
8437814 | 01 | 0.834372 | 3.67606 | M5232 5
8438607 | S02 | 0.142779 | -0.398832 | M5232 5
8438741 | S01 | 0.367346 | -0.459465 | M5232 5
8438757 | S01 | 0.271354 | -0.402595 | M5232 5
8438913 | S02 | 0.232408 | -0.976676 | M5232 5
8439125 | 01 | 0.218759 | 10.382 | M5232 5
8439460 | S01 | 0.249371 | -0.330374 | M5232 5
8439485 | S01 | 0.218798 | -0.445744 | M5232 5
8439571 | S02 | 0.10809 | -0.448798 | M5232 5
8439688 | S01 | 0.438895 | -0.412763 | M5232 5
8440555 | S02 | 0.222108 | -0.448798 | M5232 5
8440706 | S02 | 0.235539 | -4.93655 | M5232 5
8440722 | S02 | 0.65411 | -5.06047 | M5232 5
8440857 | S02 | 1.3897 | -5.09155 | M5232 5
8440871 | S02 | 1.43573 | -5.06045 | M5232 5
8441720 | 01 | 0.0534975 | 10.6095 | M5232 5; M524 4
8441741 | 01 | 0.0949854 | 10.5483 | M524 4
8441899 | 01 | 0.143858 | 10.1619 | M5232 5
8441927 | 01 | 0.0454175 | 10.2298 | M5232 5
8441942 | 01 | 0.109033 | 10.1213 | M5232 5
8441960 | 01 | 3.0147 | 7.03916 | M5232 5
8442535 | 01 | 0.320307 | 6.94252 | M5232 5
8442552 | 01 | 0.378216 | 6.93428 | M5232 5
8442713 | 01 | 0.0768874 | 6.85126 | M5232 5
8442762 | 01 | 0.0658675 | 6.9036 | M5232 5
8442809 | 01 | 0.0869752 | 6.81069 | M5232 5
8442822 | 01 | 0.0801721 | 6.66307 | M5232 5
8443184 | 01 | 0.100522 | 3.30737 | M5232 5
8443282 | 01 | 0.132567 | 3.48413 | M5232 5
8443381 | 01 | 4.02811 | -5.01056 | M5232 5
8444623 | S02 | 0.170203 | -4.8712 | M5232 15
8444692 | S02 | 0.734947 | -4.99689 | M5232 15
8444719 | S02 | 0.115071 | -4.81608 | M5232 15
8444796 | S02 | 1.81391 | -4.96336 | M5232 15
8445192 | S02 | 4.70546 | -5.09204 | M5232 15
8445211 | S02 | 0.148788 | -5.09617 | M5232 15
8445540 | 01 | 3.69197 | -5.17327 | M5232 15
8445920 | S02 | 0.0742256 | -4.10902 | M5232 3
8445923 | S02 | 0.270963 | -4.46598 | M5232 22
8445925 | S02 | 0.3583 | -4.90428 | M5232 22
8446006 | S02 | 0.00800681 | -5.01544 | M5232 22
8446158 | S02 | 0.19759 | -5.02042 | M5232 22
8452653 | 01 | 0.18311 | 6.6132 | M5232 5
8453292 | 01 | 0.750503 | 6.59712 | M5232 5
8453944 | 01 | 0.162584 | 6.59279 | M5232 5
8454007 | 01 | 2.85905 | 3.7277 | M5232 5
8497764 | S01 | 0.0667215 | 3.75103 | M5232 5 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction; Pset_FlowSegmentPipeSegment - Color: Nouvelle construction
8498532 | S01 | 0.216267 | 3.52375 | M5232 5
8498549 | S01 | 1.06013 | 3.46484 | M5232 5
8498684 | S01 | 0.376355 | 3.45838 | M5232 5
8498771 | S01 | 0.0866198 | 3.36075 | M5232 5
8498783 | S01 | 0.0884674 | 3.26679 | M5232 5
8498803 | 01 | 4.10555 | -0.90621 | M5232 5
8499067 | S01 | 0.0391346 | 0.760984 | M5232 4
8499070 | S01 | 0.0560202 | 0.618961 | M5232 5
8499362 | S01 | 0.078909 | 0.566771 | M5232 5
8499376 | S01 | 1.18922 | -0.633461 | M5232 5
8499808 | S01 | 0.0212158 | -0.684789 | M5232 5
8499977 | S02 | 1.16943 | -0.702731 | M5232 5
8500059 | S02 | 4.27751 | -4.98603 | M5232 5
8500075 | S02 | 0.0937169 | -0.628212 | M5232 5
8697375 | S02 | 0.129737 | -4.83074 | M5232 22
8697412 | S02 | 2.56888 | -4.9931 | M5232 22
8697479 | S02 | 0.147672 | -4.99707 | M5232 22
8697659 | S02 | 0.143835 | -5.00316 | M5232 22
8697673 | S02 | 1.59079 | -4.99696 | M5232 22
8837879 | S01 | 0.175185 | 3.56101 | M5232 1
8839709 | S01 | 0.0751326 | 3.61002 | M5232 1
8840308 | S01 | 0.1349 | 3.55003 | M5232 1
8840430 | S01 | 0.148558 | 3.50132 | M5232 1
8840687 | S01 | 2.65826 | 3.46069 | M5232 1
8840697 | S01 | 3.95347 | 3.50136 | M5232 1
8841167 | S01 | 0.0511033 | 3.63432 | M5232 1
8841329 | S01 | 0.176474 | 3.58465 | M5232 1
8841341 | S01 | 0.541631 | 3.51954 | M5232 1
8842076 | S01 | 0.0362085 | 3.649 | M5232 1
8842112 | S01 | 0.148203 | 3.59945 | M5232 1
8842174 | S01 | 0.0902478 | 3.59767 | M5232 1
8842222 | S01 | 0.0458802 | 3.56157 | M5232 1
8842238 | S01 | 3.7071 | 3.52847 | M5232 1
8842423 | 01 | 0.176855 | 6.90886 | M5232 1
8842559 | S01 | 0.103573 | 3.51763 | M5232 1
8842571 | S01 | 0.843258 | 3.50433 | M5232 1
8842688 | 01 | 0.107036 | 3.34788 | M5232 1
8842745 | S01 | 0.273483 | 3.3073 | M5232 1
8842796 | 01 | 3.55975 | -0.319893 | M5232 1
8843577 | 01 | 0.158356 | 6.97657 | M5232 1
8843683 | 01 | 0.176221 | 6.92728 | M5232 1
8843773 | 01 | 0.0942033 | 6.73841 | M5232 1
8843863 | 01 | 0.18484 | 6.85956 | M5232 1
8844281 | 01 | 0.225842 | 6.90879 | M5232 1
8844551 | 01 | 1.35429 | 6.83839 | M5232 1
8844561 | 01 | 4.49548 | 6.8595 | M5232 1
8845106 | 01 | 0.167555 | 6.9679 | M5232 1
8845144 | 01 | 0.176125 | 6.91576 | M5232 1
8845565 | 01 | 0.108567 | 6.95356 | M5232 1
8845598 | 01 | 0.0157756 | 6.93913 | M5232 1
8845651 | 01 | 0.610171 | 6.90626 | M5232 1
8845690 | 01 | 0.115733 | 7.14336 | M5232 1
8845812 | 01 | 0.234938 | 6.89741 | M5232 1
8845822 | 01 | 0.239892 | 6.8508 | M5232 1
8845889 | 01 | 0.147945 | 6.84812 | M5232 1
8846340 | 01 | 0.171214 | 6.84472 | M5232 1
8846352 | 01 | 3.81306 | 6.84809 | M5232 1
8846369 | 01 | 0.137238 | 6.84214 | M5232 1
8846381 | 01 | 0.719458 | 6.831 | M5232 1
8846630 | 01 | 0.18316 | 6.69783 | M5232 1
8846643 | 01 | 3.09923 | 3.53116 | M5232 1
8852095 | 01 | 6.17989 | -0.523584 | M5232 1
8879361 | S02 | 3.56088 | -5.03589 | M5232 15
8879372 | 01 | 2.84597 | -5.09613 | M5232 15
8879378 | 01 | 1.48874 | -5.0359 | M5232 15
8891387 | S01 | 0.0139426 | 3.71957 | M5232 5
8891403 | S01 | 0.357278 | 3.72769 | M5232 5
8891584 | S01 | 0.0544582 | 3.63056 | M5232 5
8891598 | S01 | 0.253283 | 3.58375 | M5232 5
8892000 | S01 | 0.0499272 | 3.67631 | M5232 5
8892027 | S01 | 0.199124 | 3.67162 | M5232 5
8892513 | 01 | 0.0356579 | 10.5697 | M5232 15

# IfcFlowSegment: Rectangular Duct:Gaine d'Air Générique_Galvanisé 3m (5)
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique_Galvanisé 3m; sets with these values: 2
Pset_ElementShading - Roughness: 0.00015 m
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Name (Rectangular Duct:Gaine d'Air Générique_Galvanisé 3m:...) | In | Length (m) | Group | Pset_ElementShading, Color = Pset_FlowSegmentDuctSegment, Color
8485655 | S01 | 1.555 | Génie climatique Reprise 1
8485679 | S01 | 0.514184 | Génie climatique Reprise 1
8607082 | S02 | 0.077 | M570HR 3 | Nouvelle construction
8893125 | 01 | 2.27074 | M570HR 1 | Nouvelle construction
8895706 | 01 | 0.590698 | M570HR 1 | Nouvelle construction

# IfcFlowSegment: Rectangular Duct:Gaine d'Air Générique_Galvanisé 6m (80)
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique_Galvanisé 6m; sets with these values: 2
Pset_ElementShading - Roughness: 0.00015 m
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Name (Rectangular Duct:Gaine d'Air Générique_Galvanisé 6m:...) | In | Length (m) | Group
7811439 | 01 | 0.749289 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7831083 | 01 | 0.1725 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7831186 | S02 | 0.390188 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7831252 | S02 | 0.215833 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7832494 | S02 | 0.511917 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7839941 | 01 | 0.0125 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7840422 | S02 | 0.47 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7840545 | S02 | 0.244896 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7841309 | S02 | 1.08848 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7842196 | S02 | 0.146699 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7842604 | S02 | 0.0551021 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7860338 | S02 | 0.159945 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
7888180 | S01 | 0.16 | Génie climatique Soufflage 1
7897371 | S01 | 0.16 | Génie climatique Soufflage 2
7897390 | S01 | 0.16 | Génie climatique Soufflage 3
7897406 | S01 | 0.16 | Génie climatique Soufflage 4
7897790 | S01 | 0.16 | Génie climatique Soufflage 5
7897822 | S01 | 0.16 | Génie climatique Soufflage 6
7897834 | S01 | 0.16 | Génie climatique Soufflage 7
7897850 | S01 | 0.16 | Génie climatique Soufflage 8
7897878 | S01 | 0.16 | Génie climatique Soufflage 9
7897974 | S01 | 0.16 | Génie climatique Soufflage 10
7897988 | S01 | 0.16 | Génie climatique Soufflage 11
7898004 | S01 | 0.16 | Génie climatique Soufflage 12
7898024 | S01 | 0.16 | Génie climatique Soufflage 13
7898055 | S01 | 0.16 | Génie climatique Soufflage 14
7898069 | S01 | 0.16 | Génie climatique Soufflage 15
7898081 | S01 | 0.16 | Génie climatique Soufflage 16
7898095 | S01 | 0.16 | Génie climatique Soufflage 17
7898262 | 01 | 0.16 | Génie climatique Soufflage 18
7898265 | 01 | 0.16 | Génie climatique Soufflage 20
7898300 | 01 | 0.16 | Génie climatique Soufflage 19
7898303 | 01 | 0.16 | Génie climatique Soufflage 22
7898319 | 01 | 0.16 | Génie climatique Soufflage 21
7898322 | 01 | 0.16 | Génie climatique Soufflage 24
7898346 | 01 | 0.16 | Génie climatique Soufflage 23
7899347 | 01 | 0.16 | Génie climatique Soufflage 25
7899350 | 01 | 0.16 | Génie climatique Soufflage 27
7899366 | 01 | 0.16 | Génie climatique Soufflage 26
7899369 | 01 | 0.16 | Génie climatique Soufflage 29
7899391 | 01 | 0.16 | Génie climatique Soufflage 28
7899394 | 01 | 0.16 | Génie climatique Soufflage 31
7899441 | 01 | 0.16 | Génie climatique Soufflage 30
7899461 | 01 | 0.16 | Génie climatique Soufflage 32
7899492 | 01 | 0.16 | Génie climatique Soufflage 33
7901249 | 01 | 0.16 | Génie climatique Soufflage 34
7901252 | 01 | 0.16 | Génie climatique Soufflage 36
7901313 | 01 | 0.07 | Génie climatique Soufflage 35
7901344 | 01 | 0.16 | Génie climatique Soufflage 37
7901347 | 01 | 0.16 | Génie climatique Soufflage 39
7901367 | 01 | 0.16 | Génie climatique Soufflage 38
7901370 | 01 | 0.16 | Génie climatique Soufflage 41
8413709 | S01 | 0.125817 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8414539 | S01 | 0.556135 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8417046 | 01 | 3.98583 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8417167 | S01 | 0.0680484 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8418487 | S01 | 0.206381 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8418567 | S01 | 0.0126279 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8418600 | S01 | 0.277269 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8418638 | S01 | 0.0126279 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8418650 | S01 | 0.0213549 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8419059 | S01 | 0.498622 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
