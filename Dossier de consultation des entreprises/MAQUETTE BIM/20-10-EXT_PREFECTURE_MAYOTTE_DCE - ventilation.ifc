Properties of the parts of a building model (IFC2X3), part 7 of 7

# IfcFlowSegment: Rectangular Duct:Gaine d'Air Générique_Galvanisé 6m (80)
Name (Rectangular Duct:Gaine d'Air Générique_Galvanisé 6m:...) | In | Length (m) | Group
8419151 | S01 | 0.404606 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8419312 | S01 | 1.65333 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421189 | S01 | 0.016314 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421424 | S01 | 0.0326279 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421429 | S01 | 0.147628 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421437 | S01 | 0.0326279 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421449 | S01 | 0.0537417 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421567 | S01 | 0.0841836 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421698 | S01 | 1.79167 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8421801 | S01 | 0.0837417 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8483980 | S01 | 0.09 | Génie climatique Soufflage 40
8570073 | S02 | 0.00650512 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8572477 | S02 | 0.462 | M570HR 4 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8833303 | 01 | 3.75645 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8833530 | 01 | 0.571716 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8833545 | 01 | 0.348002 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8837510 | S02 | 0.778193 | M570HR 2 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8850620 | S01 | 0.6425 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction

# IfcFlowSegment: Rectangular Duct:S4Rx_Generic_Rectangular, Rectangular Duct:S4Rx_Generic_Rectangular:8485234
In: S01
Pset_DistributionFlowElementCommon - Reference: S4Rx_Generic_Rectangular; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 0.63375 m; sets with these values: 2
Pset_ProductRequirements - Category: Ducts
Group: Génie climatique Reprise 1

# IfcFlowSegment: Round Duct:Gaine d'Air Générique_Galvanisé 3m (220)
Pset_DistributionFlowElementCommon - Reference: Gaine d'Air Générique_Galvanisé 3m; sets with these values: 2
Pset_ElementShading - Roughness: 0.00015 m
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Name (Round Duct:Gaine d'Air Générique_Galvanisé 3m:...) | In | Length (m) | Group
7809583 | 01 | 1.17516 | M570HR 1
7809589 | 01 | 0.550268 | M570HR 1
7809595 | 01 | 0.2943 | M570HR 1
7809599 | 01 | 1.14176 | M570HR 1
7809602 | 01 | 0.2943 | M570HR 1
7809604 | 01 | 1.11976 | M570HR 1
7809607 | 03_R+2_EL | 0.2943 | M570HR 1
7809610 | 03_R+2_EL | 1.17127 | M570HR 1
7809630 | 01 | 0.326983 | M570HR 1
7809633 | 03_R+2_EL | 0.753142 | M570HR 1
7809644 | 01 | 0.435707 | M570HR 1
7809651 | 01 | 0.210624 | M570HR 1
7809654 | 01 | 0.914139 | M570HR 1
7809658 | 01 | 0.2943 | M570HR 1
7809661 | 01 | 0.282764 | M570HR 1
7809667 | 01 | 0.175853 | M570HR 1
7809670 | 01 | 1.60445 | M570HR 1
7809679 | 01 | 0.505679 | M570HR 1
7809969 | 01 | 0.24983 | M570HR 1
7809976 | 01 | 0.0473071 | M570HR 1
7810148 | 01 | 0.24983 | M570HR 1
7811437 | 03_R+2_EL | 0.0768518 | M570HR 1
7813260 | 03_R+2_EL | 1.98404 | M570HR 1
7815271 | 03_R+2_EL | 0.159305 | M570HR 1
7815804 | 01 | 0.185389 | M570HR 1
7815836 | 01 | 0.15 | M570HR 1
7817171 | 03_R+2_EL | 0.0683644 | M570HR 1
7817197 | 03_R+2_EL | 0.218859 | M570HR 1
7818410 | 01 | 0.210624 | M570HR 1
7818420 | 01 | 0.296914 | M570HR 1
7818426 | 01 | 0.175853 | M570HR 1
7818429 | 01 | 1.67756 | M570HR 1
7818433 | 01 | 0.505679 | M570HR 1
7818437 | 01 | 0.20983 | M570HR 1
7818440 | 01 | 0.116057 | M570HR 1
7818446 | 01 | 0.11983 | M570HR 1
7818448 | 01 | 0.0892166 | M570HR 1
7819491 | 01 | 0.495 | M570HR 1
7819699 | 01 | 0.2943 | M570HR 1
7819782 | 01 | 0.3943 | M570HR 1
7819858 | 01 | 1.06101 | M570HR 1
7819933 | 01 | 0.3943 | M570HR 1
7819936 | 01 | 1.04176 | M570HR 1
7819958 | 01 | 0.3943 | M570HR 1
7819961 | 01 | 0.992257 | M570HR 1
7819978 | 01 | 0.211116 | M570HR 1
7819981 | 01 | 0.319441 | M570HR 1
7819987 | 01 | 0.2943 | M570HR 1
7819990 | 01 | 0.678293 | M570HR 1
7820052 | 01 | 0.2943 | M570HR 1
7820055 | 01 | 0.659043 | M570HR 1
7820069 | 01 | 0.2943 | M570HR 1
7820072 | 01 | 0.637043 | M570HR 1
7820123 | 01 | 2.69259 | M570HR 1
7820144 | 01 | 1.8817 | M570HR 1
7820165 | 01 | 0.320676 | M570HR 1
7820188 | 01 | 1.2905 | M570HR 1
7820213 | 01 | 1.3617 | M570HR 1
7820236 | 01 | 0.2217 | M570HR 1
7820257 | 01 | 3.26148 | M570HR 1
7820490 | 01 | 2.07284 | M570HR 1
7820670 | 01 | 1.50964 | M570HR 1
7820717 | 01 | 0.213422 | M570HR 1
7820752 | 01 | 1.45509 | M570HR 1
7820867 | 01 | 0.756735 | M570HR 2
7820870 | 01 | 0.263422 | M570HR 2
7821112 | 01 | 0.2943 | M570HR 2
7821115 | 01 | 0.839943 | M570HR 2
7821146 | 01 | 0.2943 | M570HR 2
7821149 | 01 | 0.416857 | M570HR 2
7821165 | 01 | 0.2943 | M570HR 2
7821168 | 01 | 0.438857 | M570HR 2
7821182 | 01 | 0.2943 | M570HR 2
7821185 | 01 | 0.472257 | M570HR 2
7821198 | 01 | 0.1125 | M570HR 2
7821215 | 01 | 3.1934 | M570HR 2
7821221 | 01 | 3.22658 | M570HR 2
7821308 | 01 | 1.32051 | M570HR 2
7821375 | 01 | 0.061116 | M570HR 2
7821378 | 01 | 0.046541 | M570HR 2
7821468 | 01 | 0.282724 | M570HR 2
7821501 | 01 | 2.04187 | M570HR 2
7821527 | 01 | 0.211116 | M570HR 2
7821530 | 01 | 0.443377 | M570HR 2
7821548 | 01 | 1.03102 | M570HR 2
7821712 | 01 | 0.2525 | M570HR 2
7821891 | S01 | 0.150624 | M570HR 1
7821894 | S01 | 0.274334 | M570HR 1
7821909 | S01 | 0.11983 | M570HR 1
7821918 | S01 | 0.450943 | M570HR 1
7821949 | S01 | 0.210624 | M570HR 1
7821952 | S01 | 0.266914 | M570HR 1
7822001 | S01 | 0.080624 | M570HR 1
7822004 | S01 | 0.382764 | M570HR 1
7822164 | S01 | 0.23367 | M570HR 1
7822177 | S01 | 0.691574 | M570HR 1
7822293 | S01 | 1.04477 | M570HR 1
7822316 | S01 | 0.10295 | M570HR 1
7822336 | S01 | 0.521878 | M570HR 1
7822363 | S01 | 0.0535017 | M570HR 1
7822682 | S01 | 0.2443 | M570HR 1
7822685 | S01 | 1.04391 | M570HR 1
7822687 | S01 | 0.2443 | M570HR 1
7822690 | S01 | 0.61573 | M570HR 1
7822830 | S01 | 0.471643 | M570HR 1
7822918 | S01 | 0.2443 | M570HR 1
7822921 | S01 | 1.10315 | M570HR 1
7822953 | S01 | 0.2443 | M570HR 1
7822956 | S01 | 1.10315 | M570HR 1
7822970 | S01 | 0.2443 | M570HR 1
7823023 | S01 | 2.9817 | M570HR 1
7823046 | S01 | 2.70687 | M570HR 1
7823088 | S01 | 3.37228 | M570HR 1
7824055 | 01 | 0.0799867 | M570HR 1
7824342 | 01 | 0.0226993 | M570HR 1
7824671 | S01 | 0.2443 | M570HR 2
7824674 | S01 | 0.29934 | M570HR 2
7824744 | S01 | 0.2443 | M570HR 2
7824747 | S01 | 0.722426 | M570HR 2
7824803 | S01 | 0.476316 | M570HR 2
7824806 | S01 | 0.0986409 | M570HR 2
7824811 | S01 | 0.2967 | M570HR 2
7824814 | S01 | 0.701343 | M570HR 2
7824838 | S01 | 0.2967 | M570HR 2
7824841 | S01 | 0.278257 | M570HR 2
7824846 | S01 | 0.2967 | M570HR 2
7824849 | S01 | 0.808443 | M570HR 2
7824869 | S01 | 0.2967 | M570HR 2
7824872 | S01 | 0.385357 | M570HR 2
7824877 | S01 | 0.2967 | M570HR 2
7824880 | S01 | 0.891343 | M570HR 2
7825212 | S01 | 1.58657 | M570HR 2
7825236 | S01 | 0.435861 | M570HR 2
7825258 | S01 | 1.17929 | M570HR 2
7829653 | 01 | 1.73418 | M570HR 2
7830260 | S02 | 0.210624 | M570HR 1
7830263 | S02 | 0.205268 | M570HR 1
7830267 | S02 | 0.24983 | M570HR 1
7830272 | S02 | 0.560093 | M570HR 1
7830283 | S02 | 0.210624 | M570HR 1
7830286 | S02 | 0.126914 | M570HR 1
7830299 | S02 | 0.517349 | M570HR 1
7830310 | S02 | 0.16114 | M570HR 1
7830592 | S02 | 0.899192 | M570HR 1
7830683 | S02 | 0.24983 | M570HR 1
7830688 | S02 | 0.545943 | M570HR 1
7830739 | S02 | 0.73085 | M570HR 1
7830772 | S02 | 0.469524 | M570HR 1
7830926 | S02 | 1.16493 | M570HR 1
7831014 | S02 | 0.211116 | M570HR 1
7831017 | S02 | 0.224524 | M570HR 1
7831335 | S02 | 0.211116 | M570HR 1
7831338 | S02 | 0.224524 | M570HR 1
7831365 | S02 | 0.211116 | M570HR 1
7831368 | S02 | 0.243774 | M570HR 1
7831439 | S02 | 0.379176 | M570HR 1
7831442 | S02 | 2.4 | M570HR 1
7831597 | S02 | 2.73877 | M570HR 1
7831603 | S02 | 3.47357 | M570HR 1
7831609 | S02 | 1.5817 | M570HR 1
7832365 | S02 | 2.1666 | M570HR 1
7832479 | S02 | 1.11497 | M570HR 1
7833068 | S02 | 0.246292 | M570HR 1
7833090 | S02 | 0.246292 | M570HR 1
7833155 | S02 | 0.179627 | M570HR 1
7833187 | S02 | 0.180518 | M570HR 1
7833227 | S02 | 1.75913 | M570HR 1
7833424 | S02 | 0.263868 | M570HR 1
7833469 | S02 | 0.226839 | M570HR 1
7833878 | S02 | 0.246292 | M570HR 1
7833881 | S02 | 0.179627 | M570HR 1
7840808 | S02 | 0.16855 | M570HR 2
7840818 | S02 | 2.70349 | M570HR 2
7841072 | S02 | 0.16855 | M570HR 2
7841383 | S02 | 0.210624 | M570HR 2
7841386 | S02 | 1.31313 | M570HR 2
7841406 | S02 | 0.210624 | M570HR 2
7841409 | S02 | 0.225 | M570HR 2
7841437 | S02 | 0.210624 | M570HR 2
7841440 | S02 | 0.1916 | M570HR 2
7841500 | S02 | 0.210624 | M570HR 2
7841503 | S02 | 0.1916 | M570HR 2
7841633 | S02 | 0.12 | M570HR 2
7841711 | S02 | 0.0980815 | M570HR 2
7841745 | S02 | 0.846335 | M570HR 2
7841780 | S02 | 2.16849 | M570HR 2
7841912 | S02 | 0.7617 | M570HR 2
7877335 | S02 | 0.05 | M570HR 4
8270446 | S01 | 0.00343737 | M570HR 2
8270453 | S01 | 0.311722 | M570HR 2
8270455 | S01 | 0.00343737 | M570HR 2
8270459 | S01 | 0.17965 | M570HR 2
8408462 | 01 | 0.055093 | M570HR 1
8408803 | 01 | 0.160503 | M570HR 1
8414395 | S01 | 0.144561 | M570HR 1
8414412 | S01 | 0.441138 | M570HR 1
8414863 | S01 | 0.0296513 | M570HR 1
8415657 | S01 | 0.019573 | M570HR 1
8416340 | S01 | 2.9817 | M570HR 1
8416569 | S01 | 0.0296513 | M570HR 1
8416965 | S01 | 0.0799812 | M570HR 1
8417512 | S01 | 0.269883 | M570HR 1
8418067 | 01 | 0.115785 | M570HR 1
8519241 | 01 | 0.659043 | M570HR 1
8519244 | 01 | 0.2943 | M570HR 1
8519284 | 01 | 2.87801 | M570HR 1
8611118 | S02 | 0.112473 | M570HR 1 | Pset_ElementShading - Color: Nouvelle construction; Pset_FlowSegmentDuctSegment - Color: Nouvelle construction
8611280 | S02 | 0.0634238 | M570HR 1
8611419 | S02 | 3.68053 | M570HR 1
8611463 | S02 | 0.098323 | M570HR 1
8611503 | S02 | 1.80331 | M570HR 1
8834246 | S02 | 0.505 | M570HR 3
8834285 | S02 | 0.967038 | M570HR 3
8837334 | S02 | 0.167354 | M570HR 2
8850766 | S01 | 0.295 | M570HR 1
8891322 | S01 | 0.092473 | M570HR 1
8891335 | S01 | 0.62439 | M570HR 1
8892782 | 01 | 0.177993 | M570HR 1
8892800 | 01 | 0.0998335 | M570HR 1
8892818 | 01 | 0.890879 | M570HR 1

# IfcFlowTerminal: 1200L, SA_Cistern_MEPcontent_Unspecified_Rainwater:1200L:8682794
In: S02
Type - PredefinedType: CISTERN
Pset_DistributionFlowElementCommon - Reference: 1200L; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Mechanical Equipment

# IfcFlowTerminal: GAC 10 200x33x400, VE_Air Terminal_Wall Terminal Rectangular Connector_MEPcontent_France Air Terminal_GAC_ProductCode_OUT:GAC 10 200x33x400:8507142
In: S01
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: GAC 10 200x33x400; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: France Air
Pset_ProductRequirements - Category: Air Terminals
Group: Génie climatique Reprise 1

# IfcFlowTerminal: GLA 58x366x466 (2)
In: S02
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: GLA 58x366x466; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: France Air
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Overflow_MEPcontent_France Air Terminal_GLA_ProductCode:GLA 58x366x466:...)
8572408
8607081

# IfcFlowTerminal: SA_Slop Sink_MEPcontent, SA_Slop Sink_MEPcontent:SA_Slop Sink_MEPcontent:8402814
In: S02
Type - PredefinedType: WASHHANDBASIN
Pset_DistributionFlowElementCommon - Reference: SA_Slop Sink_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures

# IfcFlowTerminal: Siphon de sol 25x25 cm_100 (13)
Type - PredefinedType: FLOORTRAP
Type - Pset_WasteTerminalTypeFloorTrap - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypeFloorWaste - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypeGreaseInterceptor - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypeGullySump - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypeGullyTrap - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypeOilInterceptor - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypePetrolInterceptor - CoverWidth: 0.25 m
Type - Pset_WasteTerminalTypeRoofDrain - CoverWidth: 0.25 m
Pset_DistributionFlowElementCommon - Reference: Siphon de sol 25x25 cm_100; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Accessories
Name (SA_Drain_Bottom Outlet Rectangular Cover_MEPcontent_Indéfini PVC_2bf3ab6b-15b8-48f8-8107-f48e4e8a0add:Siphon de sol 25x25 cm_100:...) | In | Group
8343559 | S02 | M5232 22
8343566 | S02 | M5232 22
8343920 | S02 | M5232 22
8343944 | S02 | M5232 22
8348820 | S01 | M5232 5
8349842 | 01 | M5232 15
8422226 | 01 | M5232 5
8422553 | 01 | M5232 5
8439329 | S01 | M5232 5
8440617 | S02 | M5232 5
8440921 | S02 | M5232 15
8440999 | S02 | M5232 15
8697157 | S02 | M5232 22

# IfcFlowTerminal: Siphon universel_40 (12)
Type - PredefinedType: WASTETRAP; Material: Color RGB 127-127-127
Pset_DistributionFlowElementCommon - Reference: Siphon universel_40; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Accessories
Name (SA_Siphon_S Trap_MEPcontent_Indéfini PVC_1S:Siphon universel_40:...) | In | Group
8332486 | 01 | M5232 5; M5232 9
8332781 | 01 | M5232 5; M5232 10
8333659 | 01 | M5232 5; M5232 11
8333664 | 01 | M5232 5; M5232 17
8334266 | 01 | M5232 15; M5232 14
8336535 | S01 | M5232 5; M5232 6
8336572 | S01 | M5232 5; M5232 18
8339192 | S02 | M5232 5; M5232 19
8339197 | S02 | M5232 5; M5232 24
8339880 | S02 | M5232 22; M5232 25
8445922 | S02 | M5232 22; M5232 3
8499069 | S01 | M5232 5; M5232 4

# IfcFlowTerminal: VE_Air Terminal_Grille on Duct Deflectrol_MEPcontent_IN (41)
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Grille on Duct Deflectrol_MEPcontent_IN; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Grille on Duct Deflectrol_MEPcontent_IN:VE_Air Terminal_Grille on Duct Deflectrol_MEPcontent_IN:...) | In | Group
7894183 | S01 | Génie climatique Soufflage 1
7897372 | S01 | Génie climatique Soufflage 2
7897391 | S01 | Génie climatique Soufflage 3
7897407 | S01 | Génie climatique Soufflage 4
7897791 | S01 | Génie climatique Soufflage 5
7897823 | S01 | Génie climatique Soufflage 6
7897835 | S01 | Génie climatique Soufflage 7
7897851 | S01 | Génie climatique Soufflage 8
7897879 | S01 | Génie climatique Soufflage 9
7897975 | S01 | Génie climatique Soufflage 10
7897989 | S01 | Génie climatique Soufflage 11
7898005 | S01 | Génie climatique Soufflage 12
7898025 | S01 | Génie climatique Soufflage 13
7898056 | S01 | Génie climatique Soufflage 14
7898070 | S01 | Génie climatique Soufflage 15
7898082 | S01 | Génie climatique Soufflage 16
7898096 | S01 | Génie climatique Soufflage 17
7898263 | 01 | Génie climatique Soufflage 18
7898266 | 01 | Génie climatique Soufflage 20
7898301 | 01 | Génie climatique Soufflage 19
7898304 | 01 | Génie climatique Soufflage 22
7898320 | 01 | Génie climatique Soufflage 21
7898323 | 01 | Génie climatique Soufflage 24
7898347 | 01 | Génie climatique Soufflage 23
7899348 | 01 | Génie climatique Soufflage 25
7899351 | 01 | Génie climatique Soufflage 27
7899367 | 01 | Génie climatique Soufflage 26
7899370 | 01 | Génie climatique Soufflage 29
7899392 | 01 | Génie climatique Soufflage 28
7899395 | 01 | Génie climatique Soufflage 31
7899442 | 01 | Génie climatique Soufflage 30
7899462 | 01 | Génie climatique Soufflage 32
7899493 | 01 | Génie climatique Soufflage 33
7901250 | 01 | Génie climatique Soufflage 34
7901253 | 01 | Génie climatique Soufflage 36
7901314 | 01 | Génie climatique Soufflage 35
7901345 | 01 | Génie climatique Soufflage 37
7901348 | 01 | Génie climatique Soufflage 39
7901368 | 01 | Génie climatique Soufflage 38
7901371 | 01 | Génie climatique Soufflage 41
8483981 | S01 | Génie climatique Soufflage 40

# IfcFlowTerminal: VE_Air Terminal_Grille on Duct_MEPcontent_EX, VE_Air Terminal_Grille on Duct_MEPcontent_EX:VE_Air Terminal_Grille on Duct_MEPcontent_EX:8836510
In: S02
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Grille on Duct_MEPcontent_EX; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Group: VMC 1

# IfcFlowTerminal: VE_Transfer Grille_MEPcontent (22)
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: VE_Transfer Grille_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Transfer Grille_MEPcontent:VE_Transfer Grille_MEPcontent:...) | In
8451210 | 01
8451592 | 01
8451614 | 01
8451756 | 01
8451901 | 01
8451934 | 01
8451950 | 01
8451969 | 01
8451997 | 01
8452104 | 01
8452169 | 01
8452198 | 01
8452209 | 01
8452241 | S01
8452305 | S01
8452306 | S01
8452327 | S01
8452340 | S01
8452355 | S01
8452410 | S01
8452428 | S01
8452444 | S01

# IfcFlowTerminal: bouche VMC1 (24)
Type - PredefinedType: DIFFUSER
Pset_DistributionFlowElementCommon - Reference: bouche VMC1; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Round Grille_MEPcontent_ProductCode_EX:bouche VMC1:...) | In | Group
7809571 | 01 | M570HR 1
7809572 | 01 | M570HR 1
7809573 | 01 | M570HR 1
7818402 | 01 | M570HR 1
7818403 | 01 | M570HR 1
7818404 | 01 | M570HR 1
7819074 | 01 | M570HR 1
7821374 | 01 | M570HR 2
7821526 | 01 | M570HR 2
7821889 | S01 | M570HR 1
7821890 | S01 | M570HR 1
7821948 | S01 | M570HR 1
7822000 | S01 | M570HR 1
7830258 | S02 | M570HR 1
7830259 | S02 | M570HR 1
7830282 | S02 | M570HR 1
7830682 | S02 | M570HR 1
7831013 | S02 | M570HR 1
7831334 | S02 | M570HR 1
7831364 | S02 | M570HR 1
7841382 | S02 | M570HR 2
7841405 | S02 | M570HR 2
7841436 | S02 | M570HR 2
7841499 | S02 | M570HR 2

# IfcFlowTreatmentDevice: Amortisseur L= 500_400_300 (2)
In: S02
Type - PredefinedType: RECTANGULAR
Pset_DistributionFlowElementCommon - Reference: Amortisseur L= 500_400_300; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Silencer_Rectangular_MEPcontent_Gaine d'Air Générique_Damper:Amortisseur L= 500_400_300:...) | Group
7840372 | M570HR 1
7877344 | M570HR 2
