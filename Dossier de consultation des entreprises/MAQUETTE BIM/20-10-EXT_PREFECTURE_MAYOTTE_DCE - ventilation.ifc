Properties of the parts of a building model (IFC2X3), part 5 of 7

# IfcFlowFitting: PVC (399)
Name | In | Group
SA_Tee_SW_Generic_MEPcontent:PVC:8345411 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8345466 | S02 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8345500 | S02 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8345510 | S02 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8345536 | S02 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8345695 | S02 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8345699 | S02 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8345727 | S01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8345878 | S01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8345883 | S02 | M524 4
SA_Reducer_SW_Generic_MEPcontent:PVC:8345910 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346388 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346418 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346428 | S02 | M5232 5
SA_Reducer_SW_Generic_MEPcontent:PVC:8346558 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346567 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346801 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8346806 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346833 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346872 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8346882 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8347020 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8347025 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8347666 | 01 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8347670 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8347714 | 01 | M524 1
SA_Bend_SW_Generic_MEPcontent:PVC:8347783 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8347933 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8348459 | 01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8348463 | S02 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8348798 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8349022 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8350018 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8350416 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8383936 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8383960 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8395133 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8395684 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8395688 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8396076 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8396078 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8396193 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8396265 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8396633 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8396637 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8402381 | 01 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8408094 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8408096 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8408148 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8408270 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8408274 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8408385 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8408389 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409261 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409397 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409434 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409501 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8409505 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409700 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409704 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409748 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8409809 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8409813 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8410017 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8410178 | 01 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8410182 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8411022 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8411432 | S01 | M5232 12
SA_Bend_SW_Generic_MEPcontent:PVC:8411791 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8411795 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8412333 | S01 | M5232 8
SA_Bend_SW_Generic_MEPcontent:PVC:8412560 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8412565 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8432350 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8432406 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8433001 | 01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8433005 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8433492 | 01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8433497 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8433648 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8433982 | 01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8433986 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8434069 | 01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8434073 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8434201 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8434223 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8434597 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8434778 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8434832 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8434890 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8434948 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8435077 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8435087 | 01 | M5232 5
SA_Reducer_SW_Generic_MEPcontent:PVC:8435902 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436008 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8436012 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436068 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8436072 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436311 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8436316 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436543 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436783 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436912 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8436976 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8437234 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8437580 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8437584 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8437809 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8437813 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8438752 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8438756 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8438860 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8439518 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8439929 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8440516 | S02 | M5232 5
SA_Reducer_SW_Generic_MEPcontent:PVC:8440591 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8440866 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8440870 | S02 | M5232 5
SA_Reducer_SW_Generic_MEPcontent:PVC:8441631 | 01 | M524 4
SA_Tee_SW_Generic_MEPcontent:PVC:8441740 | 01 | M524 4
SA_Bend_SW_Generic_MEPcontent:PVC:8441749 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8441764 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8441894 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8441898 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8441940 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8441959 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8441968 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8442546 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8442707 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8442712 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8442770 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8442821 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8442830 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8443178 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8443183 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8443276 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8443281 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8443376 | S02 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8443380 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8443549 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8443554 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8444197 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8445177 | S02 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8445207 | S02 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8445547 | S02 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8445551 | S02 | M5232 15
SA_Reducer_SW_Generic_MEPcontent:PVC:8445963 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8446147 | S02 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8446316 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8446331 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8446568 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8453306 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8454002 | 01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8454006 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8473591 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8479825 | 01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8498545 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8498564 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8498760 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8498781 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8498802 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8498813 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8499372 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8499385 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8499960 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8500070 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8500074 | S02 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8629765 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8630878 | S02 | M531 10
SA_Tee_SW_Generic_MEPcontent:PVC:8630958 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8630998 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8631098 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8631113 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8631128 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8631204 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8697426 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8697668 | S02 | M5232 22
SA_Tee_SW_Generic_MEPcontent:PVC:8697672 | S02 | M5232 22
SA_Bend_SW_Generic_MEPcontent:PVC:8714062 | S02 | M531 10
SA_Bend_SW_Generic_MEPcontent:PVC:8714191 | S02 | M531 3
SA_Bend_SW_Generic_MEPcontent:PVC:8837887 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8838054 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8839764 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8839774 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8840377 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8840385 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8840691 | S01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8840696 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8841204 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8841209 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8841337 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8841347 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842084 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842101 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842120 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842182 | S01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8842237 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842242 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842567 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842577 | S01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8842687 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8842791 | S01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8842795 | S01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8843611 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8843616 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8843693 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8843768 | 01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8843772 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8844300 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8844305 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8844555 | 01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8844560 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845125 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845127 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845152 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845168 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845576 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845646 | 01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8845650 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845800 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845820 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8845828 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8846347 | 01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8846351 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8846377 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8846390 | 01 | M5232 1
SA_Tee_SW_Generic_MEPcontent:PVC:8846642 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8846650 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8852279 | 01 | M5232 1
SA_Bend_SW_Generic_MEPcontent:PVC:8879359 | S02 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8879375 | S02 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8879377 | S02 | M5232 15
SA_Tee_SW_Generic_MEPcontent:PVC:8890424 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8890774 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8890779 | S01 | M5232 5
SA_Tee_SW_Generic_MEPcontent:PVC:8890998 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8891398 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8891452 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8891456 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8891594 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8891633 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8891637 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8892013 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8892131 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8892135 | S01 | M5232 5
SA_Bend_SW_Generic_MEPcontent:PVC:8892524 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8892570 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8892574 | 01 | M5232 15
SA_Bend_SW_Generic_MEPcontent:PVC:8892610 | 01 | M5232 15

# IfcFlowFitting: VE_Bend_Round_AI_Generic_MEPcontent (35)
Pset_DistributionFlowElementCommon - Reference: VE_Bend_Round_AI_Generic_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Bend_Round_AI_Generic_MEPcontent:VE_Bend_Round_AI_Generic_MEPcontent:...) | In | Group
7809593 | 01 | M570HR 1
7809649 | 01 | M570HR 1
7818497 | 01 | M570HR 1
7821212 | 01 | M570HR 2
7821652 | 01 | M570HR 2
7822174 | S01 | M570HR 1
7822347 | S01 | M570HR 1
7825185 | S01 | M570HR 2
7830602 | S02 | M570HR 1
7830777 | S02 | M570HR 1
7831257 | S02 | M570HR 1
7832373 | S02 | M570HR 1
7833484 | S02 | M570HR 1
7841314 | S02 | M570HR 2
7841645 | S02 | M570HR 2
7860340 | S02 | M570HR 2
8270449 | S01 | M570HR 2
8270451 | S01 | M570HR 2
8270457 | S01 | M570HR 2
8270461 | S01 | M570HR 2
8414408 | S01 | M570HR 1
8414424 | S01 | M570HR 1
8414936 | S01 | M570HR 1
8416347 | S01 | M570HR 1
8416869 | S01 | M570HR 1
8417051 | S01 | M570HR 1
8611167 | S02 | M570HR 1
8611171 | S02 | M570HR 1
8611432 | S02 | M570HR 1
8611508 | S02 | M570HR 1
8835699 | S02 | M570HR 3
8891332 | S01 | M570HR 1
8891347 | S01 | M570HR 1
8892813 | 01 | M570HR 1
8892832 | 01 | M570HR 1

# IfcFlowFitting: VE_EndPiece_Rectangular_AI_Generic_MEPcontent, VE_EndPiece_Rectangular_AI_Generic_MEPcontent:VE_EndPiece_Rectangular_AI_Generic_MEPcontent:8486597
In: S01
Pset_DistributionFlowElementCommon - Reference: VE_EndPiece_Rectangular_AI_Generic_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: Génie climatique Reprise 1

# IfcFlowFitting: VE_Reducer_Round_AI_Generic_MEPcontent (12)
Pset_DistributionFlowElementCommon - Reference: VE_Reducer_Round_AI_Generic_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Reducer_Round_AI_Generic_MEPcontent:VE_Reducer_Round_AI_Generic_MEPcontent:...) | In | Group
7813055 | 01 | M570HR 1
7813075 | 01 | M570HR 1
7815892 | 01 | M570HR 1
7817181 | 03_R+2_EL | M570HR 1
7820802 | 01 | M570HR 1
7821574 | 01 | M570HR 2
7821608 | 01 | M570HR 2
7829536 | S01 | M570HR 2
7832289 | S02 | M570HR 1
7833508 | S02 | M570HR 1
7842129 | S02 | M570HR 2
8879352 | 01 | M570HR 1

# IfcFlowFitting: VE_Saddle_Rectangular_AI_Generic_MEPcontent (3)
Pset_DistributionFlowElementCommon - Reference: VE_Saddle_Rectangular_AI_Generic_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Saddle_Rectangular_AI_Generic_MEPcontent:VE_Saddle_Rectangular_AI_Generic_MEPcontent:...) | In | Group
8413923 | 01 | M570HR 1
8421773 | S01 | M570HR 2
8507966 | S01 | Génie climatique Reprise 1

# IfcFlowFitting: VE_Tee_Round_AI_Generic_MEPcontent (44)
Pset_DistributionFlowElementCommon - Reference: VE_Tee_Round_AI_Generic_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Tee_Round_AI_Generic_MEPcontent:VE_Tee_Round_AI_Generic_MEPcontent:...) | In | Group
7809588 | 01 | M570HR 1
7809609 | 01 | M570HR 1
7809632 | 01 | M570HR 1
7809653 | 01 | M570HR 1
7809669 | 01 | M570HR 1
7809975 | 01 | M570HR 1
7811441 | 01 | M570HR 1
7818428 | 01 | M570HR 1
7818439 | 01 | M570HR 1
7820122 | 01 | M570HR 1
7820143 | 01 | M570HR 1
7820164 | 01 | M570HR 1
7820187 | 01 | M570HR 1
7820212 | 01 | M570HR 1
7820235 | 01 | M570HR 1
7820256 | 01 | M570HR 1
7820751 | 01 | M570HR 1
7821214 | 01 | M570HR 2
7821220 | 01 | M570HR 2
7821307 | 01 | M570HR 2
7821467 | 01 | M570HR 2
7821500 | 01 | M570HR 2
7821547 | 01 | M570HR 2
7822176 | S01 | M570HR 1
7822292 | S01 | M570HR 1
7822315 | S01 | M570HR 1
7825211 | S01 | M570HR 2
7825235 | S01 | M570HR 2
7830738 | S02 | M570HR 1
7830771 | S02 | M570HR 1
7830925 | S02 | M570HR 1
7831596 | S02 | M570HR 1
7831602 | S02 | M570HR 1
7831608 | S02 | M570HR 1
7833320 | S02 | M570HR 1
7841710 | S02 | M570HR 2
7841744 | S02 | M570HR 2
7841911 | S02 | M570HR 2
8414928 | S01 | M570HR 1
8416339 | S01 | M570HR 1
8416861 | S01 | M570HR 1
8519283 | 01 | M570HR 1
8611418 | S02 | M570HR 1
8611502 | S02 | M570HR 1

# IfcFlowFitting: With Flange (32)
Pset_DistributionFlowElementCommon - Reference: With Flange; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Name | In | Group
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:7831195 | 01 | M570HR 1 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:7831251 | S02 | M570HR 1
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:7832493 | S02 | M570HR 1
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:7841308 | S02 | M570HR 2
VE_Reducer_Rectangular_AI_Generic_MEPcontent:With Flange:7860170 | S02 | M570HR 2
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:7860337 | S02 | M570HR 2
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8413697 | 01 | M570HR 1 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8414538 | S01 | M570HR 1
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8417045 | S01 | M570HR 1
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8418576 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8418605 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8418647 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8419058 | S01 | M570HR 2
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8419136 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8419150 | S01 | M570HR 2
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8419311 | S01 | M570HR 2
VE_Reducer_Rectangular_AI_Generic_MEPcontent:With Flange:8421200 | S01 | M570HR 2
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8421420 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8421434 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8421446 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8421544 | S01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8421566 | S01 | M570HR 2
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8421697 | S01 | M570HR 2
VE_Reducer_Rectangular_AI_Generic_MEPcontent:With Flange:8507145 | S01 | Génie climatique Reprise 1
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8507964 | S01 | Génie climatique Reprise 1 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8833541 | 01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8833909 | 01 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Bend_Rectangular_AI_Generic_MEPcontent:With Flange:8833910 | S02 | M570HR 2 | Pset_PipeConnectionFlanged - FlangeThickness: 0.005 m
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8837509 | S02 | M570HR 2
VE_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8850619 | S01 | M570HR 1
VE_Reducer_Rectangular_AI_Generic_MEPcontent:With Flange:8895215 | 01 | M570HR 1
VE_Double_Tee_Rectangular_AI_Generic_MEPcontent:With Flange:8895737 | 01 | M570HR 1

# IfcFlowSegment: Flex Duct Round:Souple - Circulaire (24)
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire; sets with these values: 2
Pset_ElementShading - Roughness: 0.00009144 m
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ProductRequirements - Category: Flex Ducts
Name (Flex Duct Round:Souple - Circulaire:...) | In | Length (m) | Group
7809663 | 01 | 0.367889 | M570HR 1
7809877 | 01 | 0.521012 | M570HR 1
7810131 | 01 | 0.367889 | M570HR 1
7818422 | 01 | 0.372879 | M570HR 1
7818435 | 01 | 0.402002 | M570HR 1
7818443 | 01 | 0.372879 | M570HR 1
7820087 | 01 | 0.372879 | M570HR 1
7821451 | 01 | 0.305224 | M570HR 2
7821532 | 01 | 0.363164 | M570HR 2
7821896 | S01 | 0.363164 | M570HR 1
7821915 | S01 | 0.363164 | M570HR 1
7821954 | S01 | 0.363164 | M570HR 1
7822006 | S01 | 0.363164 | M570HR 1
7830265 | S02 | 0.449796 | M570HR 1
7830269 | S02 | 0.449796 | M570HR 1
7830288 | S02 | 0.449796 | M570HR 1
7830685 | S02 | 0.449796 | M570HR 1
7831019 | S02 | 0.449796 | M570HR 1
7831340 | S02 | 0.480789 | M570HR 1
7831370 | S02 | 0.449796 | M570HR 1
7841388 | S02 | 0.579356 | M570HR 2
7841411 | S02 | 0.579356 | M570HR 2
7841442 | S02 | 0.579356 | M570HR 2
7841505 | S02 | 0.579356 | M570HR 2

# IfcFlowSegment: Flex Pipe Round:Souple - Circulaire (5)
In: S02
Pset_DistributionFlowElementCommon - Reference: Souple - Circulaire; sets with these values: 2
Pset_ElementShading - Roughness: 0.00004572 m
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ProductRequirements - Category: Flex Pipes
Name (Flex Pipe Round:Souple - Circulaire:...) | Length (m) | Group
8475353 | 4.29932 | M532F 7
8476548 | 5.30879 | M532F 8
8476765 | 3.82002 | M531 7
8476814 | 4.36173 | M531 8
8476879 | 5.3891 | M531 9

# IfcFlowSegment: Pipe Types:Cuivre_Tuyau (731)
Pset_DistributionFlowElementCommon - Reference: Cuivre_Tuyau; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:Cuivre_Tuyau:...) | In | Pset_ElementShading, Color = Pset_FlowSegmentDuctSegment, Color = Pset_FlowSegmentPipeSegment, Color | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
7902696 | 01 | Nouvelle construction | 1.11753 | 10.7935 | M5448FF 1
7902700 | 01 | Nouvelle construction | 1.32553 | 10.796 | M5448FF 2
7902705 | 01 | Nouvelle construction | 1.33415 | 10.596 | M5448FF 2
7902707 | 01 | Nouvelle construction | 1.26025 | 10.5935 | M5448FF 1
7902719 | 01 | Nouvelle construction | 0.18 | 10.408 | M5448FF 2
7902723 | 01 | Nouvelle construction | 0.1055 | 10.392 | M5448FF 2
7902727 | 01 | Nouvelle construction | 0.064 | 10.5935 | M5448FF 1
7902731 | 01 | Nouvelle construction | 0.114 | 10.468 | M5448FF 1
7902735 | 01 | Nouvelle construction | 0.0613951 | 10.4435 | M5448FF 1
7902784 | 01 | Nouvelle construction | 0.234395 | 10.532 | M5448FF 2
7902786 | 01 | Nouvelle construction | 0.128395 | 10.5835 | M5448FF 1
7902817 | 01 | Nouvelle construction | 0.96764 | 10.5835 | M5448FF 1
7902842 | 01 | Nouvelle construction | 0.87964 | 10.532 | M5448FF 2
7902934 | 01 | Nouvelle construction | 0.235645 | 10.532 | M5448FF 2
7902936 | 01 | Nouvelle construction | 0.129645 | 10.5835 | M5448FF 1
7902940 | 01 | Nouvelle construction | 0.96764 | 10.5835 | M5448FF 1
7902944 | 01 | Nouvelle construction | 0.87964 | 10.532 | M5448FF 2
7902967 | 01 | Nouvelle construction | 0.23502 | 10.532 | M5448FF 2
7902969 | 01 | Nouvelle construction | 0.12902 | 10.5835 | M5448FF 1
7902973 | 01 | Nouvelle construction | 1.20764 | 10.5835 | M5448FF 1
7902977 | 01 | Nouvelle construction | 1.11964 | 10.532 | M5448FF 2
7903000 | 01 | Nouvelle construction | 0.234395 | 10.532 | M5448FF 2
7903002 | 01 | Nouvelle construction | 0.128395 | 10.5835 | M5448FF 1
7903006 | 01 | Nouvelle construction | 1.83401 | 10.7035 | M5448FF 1
7903010 | 01 | Nouvelle construction | 1.94601 | 10.706 | M5448FF 2
7903059 | 01 | Nouvelle construction | 0.235645 | 10.532 | M5448FF 2
7903061 | 01 | Nouvelle construction | 0.129645 | 10.5835 | M5448FF 1
7903065 | 01 | Nouvelle construction | 1.83401 | 10.7035 | M5448FF 1
7903069 | 01 | Nouvelle construction | 1.94601 | 10.706 | M5448FF 2
7903094 | 01 | Nouvelle construction | 0.116395 | 10.532 | M5448FF 2
7903096 | 01 | Nouvelle construction | 0.210395 | 10.5835 | M5448FF 1
7903100 | 01 | Nouvelle construction | 0.069013 | 10.3085 | M5448FF 1
7903104 | 01 | Nouvelle construction | 0.181013 | 10.311 | M5448FF 2
7906620 | 01 | Nouvelle construction | 0.183 | 10.608 | M5448FF 1
7906623 | 01 | Nouvelle construction | 1.034 | 10.7935 | M5448FF 1
7906663 | 01 | Nouvelle construction | 0.245 | 10.548 | M5448FF 2
7906666 | 01 | Nouvelle construction | 1.191 | 10.796 | M5448FF 2
7906713 | 01 | Nouvelle construction | 0.063 | 10.728 | M5448FF 1
7906716 | 01 | Nouvelle construction | 1.55947 | 10.7935 | M5448FF 1
7906752 | 01 | Nouvelle construction | 0.071 | 10.722 | M5448FF 2
7906755 | 01 | Nouvelle construction | 1.54325 | 10.796 | M5448FF 2
7908113 | 01 | Nouvelle construction | 0.15 | 10.548 | M5448FF 2
7908216 | 01 | Nouvelle construction | 0.084 | 10.608 | M5448FF 1
7908248 | 01 | Nouvelle construction | 0.183 | 10.608 | M5448FF 1
7908251 | 01 | Nouvelle construction | 1.33753 | 10.7935 | M5448FF 1
7908295 | 01 | Nouvelle construction | 0.245 | 10.548 | M5448FF 2
7908298 | 01 | Nouvelle construction | 1.54153 | 10.796 | M5448FF 2
7908930 | 01 | Nouvelle construction | 0.063 | 10.728 | M5448FF 1
7908933 | 01 | Nouvelle construction | 1.23221 | 10.7935 | M5448FF 1
7908968 | 01 | Nouvelle construction | 0.071 | 10.722 | M5448FF 2
7908971 | 01 | Nouvelle construction | 1.17174 | 10.796 | M5448FF 2
7908989 | 01 | Nouvelle construction | 0.084 | 10.608 | M5448FF 1
7908999 | 01 | Nouvelle construction | 0.15 | 10.548 | M5448FF 2
7913127 | 01 | Nouvelle construction | 0.961 | 10.311 | M5448FF 2
7913177 | 01 | Nouvelle construction | 0.239 | 10.333 | M5448FF 1
7913213 | 01 | Nouvelle construction | 0.197 | 10.327 | M5448FF 2
7913745 | 01 | Nouvelle construction | 1.93576 | 7.2635 | M5448FF 1
7913772 | 01 | Nouvelle construction | 1.87876 | 7.266 | M5448FF 2
7913852 | 01 | Nouvelle construction | 0.214 | 7.288 | M5448FF 1
7913864 | 01 | Nouvelle construction | 1.2 | 7.5135 | M5448FF 1
7913921 | 01 | Nouvelle construction | 1.94601 | 7.266 | M5448FF 2
7913946 | 01 | Nouvelle construction | 1.83401 | 7.2635 | M5448FF 1
7914019 | 01 | Nouvelle construction | 0.226 | 7.282 | M5448FF 2
7914029 | 01 | Nouvelle construction | 1.208 | 7.516 | M5448FF 2
7914211 | 01 | Nouvelle construction | 0.044 | 7.208 | M5448FF 1
7914221 | 01 | Nouvelle construction | 0.11325 | 7.1835 | M5448FF 1
7914279 | 01 | Nouvelle construction | 0.11 | 7.148 | M5448FF 2
7914289 | 01 | Nouvelle construction | 0.21925 | 7.132 | M5448FF 2
7914617 | 01 | Nouvelle construction | 0.06825 | 7.1835 | M5448FF 1
7914625 | 01 | Nouvelle construction | 0.87964 | 7.132 | M5448FF 2
7914629 | 01 | Nouvelle construction | 0.17425 | 7.132 | M5448FF 2
7914735 | 01 | Nouvelle construction | 0.96764 | 7.1835 | M5448FF 1
7914805 | 01 | Nouvelle construction | 0.053 | 7.208 | M5448FF 1
7914808 | 01 | Nouvelle construction | 1.25 | 7.2635 | M5448FF 1
7914846 | 01 | Nouvelle construction | 0.115 | 7.148 | M5448FF 2
7914849 | 01 | Nouvelle construction | 1.458 | 7.266 | M5448FF 2
7914890 | 01 | Nouvelle construction | 0.074 | 7.328 | M5448FF 1
7914894 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7914902 | 01 | Nouvelle construction | 0.14 | 7.268 | M5448FF 2
7914906 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7914980 | 01 | Nouvelle construction | 1.83401 | 7.4135 | M5448FF 1
7915009 | 01 | Nouvelle construction | 1.94601 | 7.416 | M5448FF 2
7915084 | 01 | Nouvelle construction | 0.073 | 7.438 | M5448FF 1
7915087 | 01 | Nouvelle construction | 0.678237 | 7.5135 | M5448FF 1
7915123 | 01 | Nouvelle construction | 0.081 | 7.432 | M5448FF 2
7915126 | 01 | Nouvelle construction | 0.551237 | 7.516 | M5448FF 2
7915188 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7915195 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7915319 | 01 | Nouvelle construction | 0.87964 | 7.252 | M5448FF 2
7915369 | 01 | Nouvelle construction | 0.96764 | 7.3035 | M5448FF 1
7915474 | 01 | Nouvelle construction | 0.183 | 7.328 | M5448FF 1
7915477 | 01 | Nouvelle construction | 1.214 | 7.5135 | M5448FF 1
7915509 | 01 | Nouvelle construction | 0.245 | 7.268 | M5448FF 2
7915512 | 01 | Nouvelle construction | 1.418 | 7.516 | M5448FF 2
7915569 | 01 | Nouvelle construction | 0.074 | 7.328 | M5448FF 1
7915571 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7915576 | 01 | Nouvelle construction | 0.14 | 7.268 | M5448FF 2
7915578 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7915583 | 01 | Nouvelle construction | 1.83401 | 7.4135 | M5448FF 1
7915585 | 01 | Nouvelle construction | 1.94601 | 7.416 | M5448FF 2
7915616 | 01 | Nouvelle construction | 0.074 | 7.328 | M5448FF 1
7915618 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7915623 | 01 | Nouvelle construction | 0.14 | 7.268 | M5448FF 2
7915625 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7915630 | 01 | Nouvelle construction | 1.83401 | 7.4135 | M5448FF 1
7915632 | 01 | Nouvelle construction | 1.94601 | 7.416 | M5448FF 2
7915659 | 01 | Nouvelle construction | 0.074 | 7.328 | M5448FF 1
7915661 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7915666 | 01 | Nouvelle construction | 0.14 | 7.268 | M5448FF 2
7915668 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7915673 | 01 | Nouvelle construction | 1.83401 | 7.4135 | M5448FF 1
7915675 | 01 | Nouvelle construction | 1.94601 | 7.416 | M5448FF 2
7915727 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7915730 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7915733 | 01 | Nouvelle construction | 0.87964 | 7.252 | M5448FF 2
7915735 | 01 | Nouvelle construction | 0.96764 | 7.3035 | M5448FF 1
7915758 | 01 | Nouvelle construction | 0.06825 | 7.3035 | M5448FF 1
7915761 | 01 | Nouvelle construction | 0.17425 | 7.252 | M5448FF 2
7915764 | 01 | Nouvelle construction | 0.87964 | 7.252 | M5448FF 2
7915766 | 01 | Nouvelle construction | 0.96764 | 7.3035 | M5448FF 1
7915812 | 01 | Nouvelle construction | 0.183 | 7.328 | M5448FF 1
7915815 | 01 | Nouvelle construction | 1.17782 | 7.5135 | M5448FF 1
7915853 | 01 | Nouvelle construction | 0.245 | 7.268 | M5448FF 2
7915856 | 01 | Nouvelle construction | 1.33319 | 7.516 | M5448FF 2
7915889 | 01 | Nouvelle construction | 0.081 | 7.432 | M5448FF 2
7915892 | 01 | Nouvelle construction | 0.234 | 7.516 | M5448FF 2
7915925 | 01 | Nouvelle construction | 0.073 | 7.438 | M5448FF 1
7915928 | 01 | Nouvelle construction | 0.43 | 7.5135 | M5448FF 1
7915963 | 01 | Nouvelle construction | 0.081 | 7.432 | M5448FF 2
7915966 | 01 | Nouvelle construction | 1.78561 | 7.516 | M5448FF 2
7915999 | 01 | Nouvelle construction | 0.073 | 7.438 | M5448FF 1
7916002 | 01 | Nouvelle construction | 1.84497 | 7.5135 | M5448FF 1
7916035 | 01 | Nouvelle construction | 0.081 | 7.432 | M5448FF 2
7916038 | 01 | Nouvelle construction | 0.026092 | 7.516 | M5448FF 2
7916071 | 01 | Nouvelle construction | 0.073 | 7.438 | M5448FF 1
7916074 | 01 | Nouvelle construction | 0.106898 | 7.5135 | M5448FF 1
7916120 | 01 | Nouvelle construction | 0.183 | 7.328 | M5448FF 1
7916123 | 01 | Nouvelle construction | 1.214 | 7.5135 | M5448FF 1
7916156 | 01 | Nouvelle construction | 0.245 | 7.268 | M5448FF 2
7916159 | 01 | Nouvelle construction | 1.418 | 7.516 | M5448FF 2
8073118 | 01 | Nouvelle construction | 0.0424537 | 7.20795 | M5448FF 5
8073120 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073125 | 01 | Nouvelle construction | 0.135954 | 7.14795 | M5448FF 6
8073127 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073170 | 01 | Nouvelle construction | 0.0424488 | 7.20795 | M5448FF 5
8073172 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073177 | 01 | Nouvelle construction | 0.135949 | 7.14795 | M5448FF 6
8073179 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073230 | 01 | Nouvelle construction | 0.0424537 | 7.20795 | M5448FF 5
8073232 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073237 | 01 | Nouvelle construction | 0.108454 | 7.14795 | M5448FF 6
8073239 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073284 | 01 | Nouvelle construction | 0.042454 | 7.20795 | M5448FF 5
8073286 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073291 | 01 | Nouvelle construction | 0.108454 | 7.14795 | M5448FF 6
8073293 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073357 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073360 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073401 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073404 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073441 | 01 | Nouvelle construction | 0.06825 | 7.18345 | M5448FF 5
8073444 | 01 | Nouvelle construction | 0.17425 | 7.13195 | M5448FF 6
8073699 | 01 | Nouvelle construction | 1.58801 | 7.2619 | M5448FF 5
8073725 | 01 | Nouvelle construction | 1.439 | 7.2919 | M5448FF 6
8075073 | 01 | Nouvelle construction | 1.4715 | 7.2919 | M5448FF 6
8075100 | 01 | Nouvelle construction | 1.58801 | 7.2619 | M5448FF 5
8075133 | 01 | Nouvelle construction | 1.4965 | 7.2644 | M5448FF 6
8075157 | 01 | Nouvelle construction | 1.58801 | 7.2619 | M5448FF 5
8075180 | 01 | Nouvelle construction | 0.71764 | 7.18345 | M5448FF 5
8075203 | 01 | Nouvelle construction | 0.62964 | 7.13195 | M5448FF 6
8075226 | 01 | Nouvelle construction | 0.71764 | 7.18345 | M5448FF 5
8075248 | 01 | Nouvelle construction | 0.62964 | 7.13195 | M5448FF 6
8075270 | 01 | Nouvelle construction | 1.5015 | 7.2644 | M5448FF 6
8075297 | 01 | Nouvelle construction | 1.58801 | 7.2619 | M5448FF 5
8075322 | 01 | Nouvelle construction | 0.71764 | 7.18345 | M5448FF 5
8075344 | 01 | Nouvelle construction | 0.62964 | 7.13195 | M5448FF 6
8076534 | 01 | Nouvelle construction | 0.0424537 | 7.20795 | M5448FF 5
8076574 | 01 | Nouvelle construction | 0.108454 | 7.14795 | M5448FF 6
8078831 | 01 | Nouvelle construction | 0.113454 | 7.14795 | M5448FF 6
8078873 | 01 | Nouvelle construction | 0.0514537 | 7.20795 | M5448FF 5
8078922 | 01 | Nouvelle construction | 0.0669463 | 7.057
8078960 | 01 | Nouvelle construction | 0.0514537 | 7.20795 | M5448FF 5
8079428 | 01 | Nouvelle construction | 0.563616 | 7.2619 | M5448FF 5
8079439 | 01 | Nouvelle construction | 1.205 | 7.2619 | M5448FF 5
8079466 | 01 | Nouvelle construction | 0.0661421 | 7.21597 | M5448FF 6
8079483 | 01 | Nouvelle construction | 0.0846602 | 7.21197 | M5448FF 6
8079491 | 01 | Nouvelle construction | 0.0631421 | 7.21597 | M5448FF 6
8079530 | 01 | Nouvelle construction | 0.594139 | 7.2644 | M5448FF 6
8079540 | 01 | Nouvelle construction | 1.413 | 7.2644 | M5448FF 6
8079586 | 01 | Nouvelle construction | 0.0917043 | 7.2619 | M5448FF 5
8079595 | 01 | Nouvelle construction | 1.214 | 7.2619 | M5448FF 5
8079622 | 01 | Nouvelle construction | 0.0676066 | 7.21494 | M5448FF 6
8079632 | 01 | Nouvelle construction | 0.0875891 | 7.21094 | M5448FF 6
8079640 | 01 | Nouvelle construction | 0.0646066 | 7.21494 | M5448FF 6
8079727 | 01 | Nouvelle construction | 1.418 | 7.2644 | M5448FF 6
8079825 | 01 | Nouvelle construction | 1.214 | 7.2619 | M5448FF 5
8079852 | 01 | Nouvelle construction | 0.0634645 | 7.24537 | M5448FF 6
8079862 | 01 | Nouvelle construction | 0.145947 | 7.24137 | M5448FF 6
8079875 | 01 | Nouvelle construction | 0.0215736 | 7.24537 | M5448FF 6
8079914 | 01 | Nouvelle construction | 1.14309 | 7.2644 | M5448FF 6
8080027 | 01 | Nouvelle construction | 0.342 | 7.2619 | M5448FF 5
8080036 | 01 | Nouvelle construction | 2.36817 | 7.2619 | M5448FF 5
8080063 | 01 | Nouvelle construction | 0.0655355 | 7.2439 | M5448FF 6
8080075 | 01 | Nouvelle construction | 0.175518 | 7.2399 | M5448FF 6
8080083 | 01 | Nouvelle construction | 0.0236447 | 7.2439 | M5448FF 6
8080118 | 01 | Nouvelle construction | 0.15 | 7.2644 | M5448FF 6
8080126 | 01 | Nouvelle construction | 2.54907 | 7.2644 | M5448FF 6
8080265 | 01 | Nouvelle construction | 0.190112 | 6.96492 | M5448FF 5
8080267 | 01 | Nouvelle construction | 0.0961123 | 6.96742 | M5448FF 6
8080294 | 01 | Nouvelle construction | 0.0595779 | 6.98342 | M5448FF 6
8080327 | 01 | Nouvelle construction | 0.0415779 | 6.98942 | M5448FF 5
8270476 | S01 | Nouvelle construction | 0.124054 | 3.75795 | M5448FF 5
8270478 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270483 | S01 | Nouvelle construction | 0.124049 | 3.75795 | M5448FF 5
8270485 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270490 | S01 | Nouvelle construction | 0.124054 | 3.75795 | M5448FF 5
8270492 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270497 | S01 | Nouvelle construction | 0.124054 | 3.75795 | M5448FF 5
8270499 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270504 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270507 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270510 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270513 | S01 | Nouvelle construction | 1.60301 | 3.8935 | M5448FF 5
8270515 | S01 | Nouvelle construction | 1.60301 | 3.8935 | M5448FF 5
8270517 | S01 | Nouvelle construction | 1.60301 | 3.8935 | M5448FF 5
8270519 | S01 | Nouvelle construction | 0.70264 | 3.73345 | M5448FF 5
8270521 | S01 | Nouvelle construction | 0.70264 | 3.73345 | M5448FF 5
8270523 | S01 | Nouvelle construction | 1.60301 | 3.8935 | M5448FF 5
8270525 | S01 | Nouvelle construction | 0.70264 | 3.73345 | M5448FF 5
8270546 | S01 | Nouvelle construction | 0.124054 | 3.75795 | M5448FF 5
8270555 | S01 | Nouvelle construction | 0.133054 | 3.75795 | M5448FF 5
8270568 | S01 | Nouvelle construction | 0.133054 | 3.75795 | M5448FF 5
8270581 | S01 | Nouvelle construction | 0.356491 | 3.8935 | M5448FF 5
8270587 | S01 | Nouvelle construction | 2.00594 | 3.8935 | M5448FF 5
8270591 | S01 | Nouvelle construction | 0.52699 | 3.8935 | M5448FF 5
8270597 | S01 | Nouvelle construction | 2.41525 | 3.8935 | M5448FF 5
8270606 | S01 | Nouvelle construction | 2.21525 | 3.8935 | M5448FF 5
8270611 | S01 | Nouvelle construction | 0.52825 | 3.8935 | M5448FF 5
8270617 | S01 | Nouvelle construction | 1.999 | 3.8935 | M5448FF 5
8270625 | S01 | Nouvelle construction | 0.190054 | 3.69795 | M5448FF 6
8270627 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270632 | S01 | Nouvelle construction | 0.190049 | 3.69795 | M5448FF 6
8270634 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270639 | S01 | Nouvelle construction | 0.190054 | 3.69795 | M5448FF 6
8270641 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270646 | S01 | Nouvelle construction | 0.190054 | 3.69795 | M5448FF 6
8270648 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270653 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270656 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270659 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270662 | S01 | Nouvelle construction | 1.4799 | 3.896 | M5448FF 6
8270666 | S01 | Nouvelle construction | 1.4749 | 3.896 | M5448FF 6
8270670 | S01 | Nouvelle construction | 1.4774 | 3.896 | M5448FF 6
8270674 | S01 | Nouvelle construction | 0.61464 | 3.68195 | M5448FF 6
8270676 | S01 | Nouvelle construction | 0.61464 | 3.68195 | M5448FF 6
8270678 | S01 | Nouvelle construction | 1.4799 | 3.896 | M5448FF 6
8270682 | S01 | Nouvelle construction | 0.61464 | 3.68195 | M5448FF 6
8270707 | S01 | Nouvelle construction | 0.190054 | 3.69795 | M5448FF 6
8270716 | S01 | Nouvelle construction | 0.195054 | 3.69795 | M5448FF 6
8270729 | S01 | Nouvelle construction | 0.195054 | 3.69795 | M5448FF 6
8270742 | S01 | Nouvelle construction | 0.0684049 | 3.84597 | M5448FF 6
8270746 | S01 | Nouvelle construction | 0.11806 | 3.84197 | M5448FF 6
8270750 | S01 | Nouvelle construction | 0.0654049 | 3.84597 | M5448FF 6
8270752 | S01 | Nouvelle construction | 0.334632 | 3.896 | M5448FF 6
8270757 | S01 | Nouvelle construction | 2.21394 | 3.896 | M5448FF 6
8270767 | S01 | Nouvelle construction | 0.0663338 | 3.84744 | M5448FF 6
8270771 | S01 | Nouvelle construction | 0.123489 | 3.84344 | M5448FF 6
8270775 | S01 | Nouvelle construction | 0.0633338 | 3.84744 | M5448FF 6
8270777 | S01 | Nouvelle construction | 0.406251 | 3.896 | M5448FF 6
8270782 | S01 | Nouvelle construction | 2.61925 | 3.896 | M5448FF 6
8270793 | S01 | Nouvelle construction | 0.0692627 | 3.84537 | M5448FF 6
8270797 | S01 | Nouvelle construction | 0.121847 | 3.84137 | M5448FF 6
8270801 | S01 | Nouvelle construction | 0.0662627 | 3.84537 | M5448FF 6
8270806 | S01 | Nouvelle construction | 2.41925 | 3.896 | M5448FF 6
8270817 | S01 | Nouvelle construction | 0.0642627 | 3.8489 | M5448FF 6
8270821 | S01 | Nouvelle construction | 0.123918 | 3.8449 | M5448FF 6
8270825 | S01 | Nouvelle construction | 0.0612627 | 3.8489 | M5448FF 6
8270827 | S01 | Nouvelle construction | 0.33625 | 3.896 | M5448FF 6
8270832 | S01 | Nouvelle construction | 2.203 | 3.896 | M5448FF 6
8270846 | S01 | Nouvelle construction | 0.06825 | 3.73345 | M5448FF 5
8270849 | S01 | Nouvelle construction | 0.70264 | 3.73345 | M5448FF 5
8270855 | S01 | Nouvelle construction | 0.17425 | 3.68195 | M5448FF 6
8270858 | S01 | Nouvelle construction | 0.61464 | 3.68195 | M5448FF 6
8270868 | S01 | Nouvelle construction | 0.195054 | 3.69795 | M5448FF 6
8270871 | S01 | Nouvelle construction | 0.225352 | 3.896 | M5448FF 6
8270883 | S01 | Nouvelle construction | 0.133054 | 3.75795 | M5448FF 5
8270886 | S01 | Nouvelle construction | 0.314744 | 3.8935 | M5448FF 5
8273855 | S01 | Nouvelle construction | 1.062 | 3.94413 | M5448FF 9
8273859 | S01 | Nouvelle construction | 1.94601 | 3.94663 | M5448FF 10
8273863 | S01 | Nouvelle construction | 1.83401 | 3.94413 | M5448FF 9
8273877 | S01 | Nouvelle construction | 1.07 | 3.94663 | M5448FF 10
8273885 | S01 | Nouvelle construction | 0.174547 | 3.75808 | M5448FF 9
8273889 | S01 | Nouvelle construction | 0.11325 | 3.73358 | M5448FF 9
8273898 | S01 | Nouvelle construction | 0.240547 | 3.69808 | M5448FF 10
8273902 | S01 | Nouvelle construction | 0.21925 | 3.68208 | M5448FF 10
8273911 | S01 | Nouvelle construction | 0.06825 | 3.73358 | M5448FF 9
8273914 | S01 | Nouvelle construction | 0.83364 | 3.73608 | M5448FF 10
8273916 | S01 | Nouvelle construction | 0.17425 | 3.68208 | M5448FF 10
8273920 | S01 | Nouvelle construction | 0.96764 | 3.73358 | M5448FF 9
8273923 | S01 | Nouvelle construction | 0.183547 | 3.75808 | M5448FF 9
8273926 | S01 | Nouvelle construction | 1.25266 | 3.94413 | M5448FF 9
8273938 | S01 | Nouvelle construction | 0.191547 | 3.75208 | M5448FF 10
8273941 | S01 | Nouvelle construction | 1.46066 | 3.94663 | M5448FF 10
8273953 | S01 | Nouvelle construction | 0.074 | 3.75862 | M5448FF 9
8273955 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8273960 | S01 | Nouvelle construction | 0.14 | 3.69862 | M5448FF 10
8273962 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8273967 | S01 | Nouvelle construction | 1.83401 | 3.84413
8273969 | S01 | Nouvelle construction | 1.94601 | 3.84662
8274007 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8274010 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8274013 | S01 | Nouvelle construction | 0.87964 | 3.68262 | M5448FF 10
8274015 | S01 | Nouvelle construction | 0.96764 | 3.73413 | M5448FF 9
8274019 | S01 | Nouvelle construction | 0.183 | 3.75862 | M5448FF 9
8274022 | S01 | Nouvelle construction | 0.900044 | 3.94413 | M5448FF 9
8274034 | S01 | Nouvelle construction | 0.245 | 3.69862 | M5448FF 10
8274037 | S01 | Nouvelle construction | 1.0905 | 3.94663 | M5448FF 10
8274049 | S01 | Nouvelle construction | 0.109 | 3.75862 | M5448FF 9
8274051 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8274056 | S01 | Nouvelle construction | 0.175 | 3.69862 | M5448FF 10
8274058 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8274063 | S01 | Nouvelle construction | 1.83401 | 3.87913 | M5448FF 9
8274065 | S01 | Nouvelle construction | 1.94601 | 3.88163 | M5448FF 10
8274073 | S01 | Nouvelle construction | 0.074 | 3.75862 | M5448FF 9
8274075 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8274080 | S01 | Nouvelle construction | 0.14 | 3.69862 | M5448FF 10
8274082 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8274087 | S01 | Nouvelle construction | 1.83401 | 3.84413 | M5448FF 9
8274089 | S01 | Nouvelle construction | 1.94601 | 3.84662 | M5448FF 10
8274121 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8274124 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8274127 | S01 | Nouvelle construction | 0.87964 | 3.68262 | M5448FF 10
8274129 | S01 | Nouvelle construction | 0.96764 | 3.73413 | M5448FF 9
8274133 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8274136 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8274139 | S01 | Nouvelle construction | 0.87964 | 3.68262 | M5448FF 10
8274141 | S01 | Nouvelle construction | 0.96764 | 3.73413 | M5448FF 9
8274175 | S01 | Nouvelle construction | 0.046 | 3.89763 | M5448FF 10
8274178 | S01 | Nouvelle construction | 1.70705 | 3.94663 | M5448FF 10
8274190 | S01 | Nouvelle construction | 0.038 | 3.90362 | M5448FF 9
8274193 | S01 | Nouvelle construction | 1.76124 | 3.94413 | M5448FF 9
8274205 | S01 | Nouvelle construction | 0.081 | 3.86262 | M5448FF 10
8274208 | S01 | Nouvelle construction | 1.47777 | 3.94663 | M5448FF 10
8274220 | S01 | Nouvelle construction | 0.073 | 3.86863 | M5448FF 9
8274223 | S01 | Nouvelle construction | 1.53036 | 3.94413 | M5448FF 9
8274265 | S01 | Nouvelle construction | 0.183 | 3.75862 | M5448FF 9
8274268 | S01 | Nouvelle construction | 1.25173 | 3.94413 | M5448FF 9
8274280 | S01 | Nouvelle construction | 0.245 | 3.69862 | M5448FF 10
8274283 | S01 | Nouvelle construction | 1.3792 | 3.94663 | M5448FF 10
8274417 | S01 | Nouvelle construction | 0.06825 | 3.73413 | M5448FF 9
8274420 | S01 | Nouvelle construction | 0.17425 | 3.68262 | M5448FF 10
8274423 | S01 | Nouvelle construction | 0.87964 | 3.68262 | M5448FF 10
8274425 | S01 | Nouvelle construction | 0.96764 | 3.73413 | M5448FF 9
8274505 | S01 | Nouvelle construction | 0.151 | 3.68262
8274551 | S01 | Nouvelle construction | 0.183 | 3.75862 | M5448FF 9
8274554 | S01 | Nouvelle construction | 1.2165 | 3.94413 | M5448FF 9
8274589 | S01 | Nouvelle construction | 0.245 | 3.69862 | M5448FF 10
8274592 | S01 | Nouvelle construction | 1.42036 | 3.94663 | M5448FF 10
8274628 | S01 | Nouvelle construction | 0.183 | 3.75862 | M5448FF 9
8274631 | S01 | Nouvelle construction | 1.21636 | 3.94413 | M5448FF 9
8276035 | S01 | Nouvelle construction | 1.424 | 3.94413 | M5448FF 9
8276047 | S01 | Nouvelle construction | 0.5865 | 3.94413 | M5448FF 9
8276093 | S01 | Nouvelle construction | 1.436 | 3.94663 | M5448FF 10
8276103 | S01 | Nouvelle construction | 0.4985 | 3.94663 | M5448FF 10
8276242 | S01 | Nouvelle construction | 0.1935 | -0.355875 | M5448FF 9
8276271 | S01 | Nouvelle construction | 0.2115 | -0.353375 | M5448FF 10
8276387 | S01 | Nouvelle construction | 0.40975 | -0.355875 | M5448FF 1
8276389 | S01 | Nouvelle construction | 0.50175 | -0.353375 | M5448FF 2
8276393 | S02 | Nouvelle construction | 4.66994 | -0.355875 | M5448FF 1
8277088 | S02 | Nouvelle construction | 6.066 | -0.4256 | M5448FF 6
8277111 | S02 | Nouvelle construction | 6.254 | -0.4281 | M5448FF 5
8277659 | S02 | Nouvelle construction | 0.350112 | -1.00398 | M5448FF 9
8277661 | S02 | Nouvelle construction | 0.436112 | -1.00148 | M5448FF 10
8277679 | S02 | Nouvelle construction | 0.350112 | -1.00398 | M5448FF 9
8277681 | S02 | Nouvelle construction | 0.436112 | -1.00148 | M5448FF 10
8277695 | S02 | Nouvelle construction | 0.350112 | -1.00398 | M5448FF 9
8277697 | S02 | Nouvelle construction | 0.436112 | -1.00148 | M5448FF 10
8277701 | S02 | Nouvelle construction | 0.624109 | -0.985484 | M5448FF 10
8277707 | S02 | Nouvelle construction | 0.612109 | -0.979484 | M5448FF 9
8277719 | S02 | Nouvelle construction | 0.210112 | -1.00398 | M5448FF 9
8277721 | S02 | Nouvelle construction | 0.116112 | -1.00148 | M5448FF 10
8277725 | S02 | Nouvelle construction | 0.502228 | -0.985484 | M5448FF 10
8277734 | S02 | Nouvelle construction | 0.488228 | -0.979484 | M5448FF 9
8277757 | S02 | Nouvelle construction | 0.25644 | -0.355875 | M5448FF 9
8277759 | S02 | Nouvelle construction | 0.08444 | -0.353375 | M5448FF 10
8277897 | S02 | Nouvelle construction | 0.621109 | -0.979484 | M5448FF 9
8277900 | S02 | Nouvelle construction | 3.973 | -0.355875 | M5448FF 9
8277936 | S02 | Nouvelle construction | 0.629109 | -0.985484 | M5448FF 10
8277939 | S02 | Nouvelle construction | 3.981 | -0.353375 | M5448FF 10
8277972 | S02 | Nouvelle construction | 0.621109 | -0.979484 | M5448FF 9
8277975 | S02 | Nouvelle construction | 1.362 | -0.355875 | M5448FF 9
8278004 | S02 | Nouvelle construction | 0.629109 | -0.985484 | M5448FF 10
8278007 | S02 | Nouvelle construction | 1.366 | -0.353375 | M5448FF 10
8278029 | S02 | Nouvelle construction | 4.12694 | -0.353375 | M5448FF 10
8278052 | S02 | Nouvelle construction | 3.93894 | -0.355875 | M5448FF 9
8281827 | S02 | Nouvelle construction | 3.65351 | -0.479756 | M5448FF 9
8281831 | S02 | Nouvelle construction | 3.66551 | -0.475256 | M5448FF 10
8281843 | S02 | Nouvelle construction | 0.461863 | -0.479756 | M5448FF 9
8281847 | S02 | Nouvelle construction | 0.453863 | -0.475256 | M5448FF 10
8281855 | S02 | Nouvelle construction | 0.0968812 | -0.455256 | M5448FF 9
8281858 | S02 | Nouvelle construction | 1.652 | -0.355875 | M5448FF 9
8281870 | S02 | Nouvelle construction | 0.102881 | -0.459256 | M5448FF 10
8281873 | S02 | Nouvelle construction | 1.656 | -0.353375 | M5448FF 10
8318798 | S02 | Nouvelle construction | 4.86194 | -0.353375 | M5448FF 2
8318867 | S02 | Nouvelle construction | 12.174 | -0.355875 | M5448FF 1
8318870 | S02 | Nouvelle construction | 12.346 | -0.353375 | M5448FF 2
8321298 | S02 | Nouvelle construction | 2.299 | -0.4281 | M5448FF 5
8321302 | S02 | Nouvelle construction | 5.46649 | -0.353375 | M5448FF 2
8321305 | S02 | Nouvelle construction | 1.406 | -0.353375 | M5448FF 2
8321309 | S02 | Nouvelle construction | 5.45449 | -0.355875 | M5448FF 1
8321312 | S02 | Nouvelle construction | 1.374 | -0.355875 | M5448FF 1
8321326 | S02 | Nouvelle construction | 2.63545 | -0.353375 | M5448FF 2
8321330 | S02 | Nouvelle construction | 2.54945 | -0.355875 | M5448FF 1
8321362 | S02 | Nouvelle construction | 2.205 | -0.4256 | M5448FF 6
8321413 | S02 | Nouvelle construction | 0.726 | -0.4081 | M5448FF 13
8321419 | S02 | Nouvelle construction | 0.714 | -0.4106 | M5448FF 14
8321429 | S02 | Nouvelle construction | 1.3435 | -1.7596 | M5448FF 13
8321437 | S02 | Nouvelle construction | 1.35025 | -1.77235 | M5448FF 14
8329057 | 01 | Nouvelle construction | 1.296 | 10.311 | M5448FF 2
8329081 | 01 | Nouvelle construction | 0.949 | 10.3085 | M5448FF 1
8329090 | 01 | Nouvelle construction | 1.284 | 10.3085 | M5448FF 1
8358510 | S02 | Nouvelle construction | 0.0659984 | -0.452825 | M531 3
8358637 | S02 | Nouvelle construction | 2.30255 | -2.76938 | M531 3
8358663 | S02 | Nouvelle construction | 2.429 | -0.455325 | M531 3
8358680 | S02 | Nouvelle construction | 0.629 | -0.455325 | M531 3
8358734 | S02 | Nouvelle construction | 3.12255 | -3.58937 | M531 3
8358768 | S02 | Nouvelle construction | 0.0709984 | -0.452825 | M531 3
8358824 | S02 | Nouvelle construction | 3.36855 | -3.82938 | M531 3
8358847 | S02 | Nouvelle construction | 3.36855 | -3.82938 | M531 3
8358973 | S02 | Nouvelle construction | 0.0496135 | -0.458725 | M531 3
8359945 | S02 | Nouvelle construction | 0.221571 | -0.455325 | M531 3
8359956 | S02 | Nouvelle construction | 0.08675 | -0.458725 | M531 3
8359982 | S02 | Nouvelle construction | 1.37525 | -0.458725 | M531 3
8359991 | S02 | Nouvelle construction | 0.219 | -0.452825 | M531 3
8360073 | S02 | Nouvelle construction | 0.102571 | -0.452825 | M531 3
8382388 | S02 | Nouvelle construction | 0.2115 | -0.458725 | M531 3
8382432 | S02 | Nouvelle construction | 3.96917 | -4.444 | M531 3
8382449 | S02 | Nouvelle construction | 0.0389737 | -4.4799 | M531 3
8383223 | S02 | Nouvelle construction | 0.8 | -4.62 | M531 4
8383248 | S02 | Nouvelle construction | 1.39 | -4.61 | M531 5
8383285 | S02 | Nouvelle construction | 1.39 | -4.61 | M532F 1
8383615 | S02 | Nouvelle construction | 1.39 | -4.61 | M531 6
8383617 | S02 | Nouvelle construction | 1.39 | -4.61 | M532F 2
8383640 | S02 | Nouvelle construction | 0.45671 | -4.3615 | M531 3
8384042 | S02 | Nouvelle construction | 0.152 | 0.4935 | M531 3
8384118 | S01 | Nouvelle construction | 0.2715 | 0.4935 | M531 3
8384785 | S01 | Nouvelle construction | 0.0671306 | 0.4935 | M531 3
8384851 | S01 | Nouvelle construction | 0.0761306 | 0.4935 | M531 3
8384895 | S01 | Nouvelle construction | 0.149644 | 0.4935 | M531 3
8384911 | S01 | Nouvelle construction | 0.122 | 0.518 | M531 3
8384956 | S01 | Nouvelle construction | 0.875606 | 0.4935 | M531 3
8384960 | S01 | Nouvelle construction | 0.047 | 0.435 | M531 3
8385041 | S01 | Nouvelle construction | 0.082 | 0.435 | M532F 3
8385071 | S01 | Nouvelle construction | 0.034 | 0.5285 | M532F 3
8385196 | S01 | Nouvelle construction | 0.087 | 0.553 | M532F 3
8385313 | S01 | Nouvelle construction | 1.01196 | -0.326955 | M531 3
8385341 | S01 | Nouvelle construction | 2.26704 | 1.518 | M532F 4
8385444 | S01 | Nouvelle construction | 0.3658 | 0.5285 | M532F 3
8385503 | S01 | Nouvelle construction | 0.034 | 0.5285 | M532F 3
8385874 | S01 | Nouvelle construction | 1.01196 | -0.326955 | M531 3
8385894 | S01 | Nouvelle construction | 1.01196 | -0.326955 | M531 3
8385935 | S01 | Nouvelle construction | 1.119 | -0.323955 | M531 3
8386307 | S01 | Nouvelle construction | 1.53219 | -0.348455 | M531 3
8386676 | S01 | Nouvelle construction | 0.4765 | -0.348455 | M531 3
8386711 | S01 | Nouvelle construction | 0.468331 | -0.346955 | M531 3
8386740 | S02 | Nouvelle construction | 0.301862 | -0.351855 | M531 3
8386860 | S01 | Nouvelle construction | 0.472331 | -0.346955 | M531 3
8386874 | S02 | Nouvelle construction | 1.36611 | -0.346955 | M531 3
8386905 | S02 | Nouvelle construction | 0.815251 | -0.348455 | M531 3
8386972 | S01 | Nouvelle construction | 0.466331 | -0.346955 | M531 3
8387114 | S01 | Nouvelle construction | 0.111306 | 3.79654 | M532F 4
8387456 | S02 | Nouvelle construction | 0.728345 | -0.351855 | M531 3
8387478 | S01 | Nouvelle construction | 0.0633694 | 3.79654 | M531 3
8387758 | S01 | Nouvelle construction | 1.03896 | -0.323955 | M531 3
8387829 | S02 | Nouvelle construction | 0.058 | 3.60704 | M531 3
8387895 | 01 | Nouvelle construction | 0.0940333 | 3.60704 | M531 3
8387941 | 01 | Nouvelle construction | 0.859474 | 3.49544 | M531 3
8387951 | 01 | Nouvelle construction | 3.72015 | 3.49544 | M531 3
8387975 | 01 | Nouvelle construction | 0.072 | 3.61194 | M531 3
8387992 | 01 | Nouvelle construction | 0.14864 | 3.60704 | M531 3
8388002 | 01 | Nouvelle construction | 0.24936 | 3.49694 | M531 3
8388073 | 01 | Nouvelle construction | 0.321 | 3.51494 | M531 3
8388251 | 01 | Nouvelle construction | 1.32306 | 3.63194 | M531 3
8388292 | 01 | Nouvelle construction | 1.43806 | 3.51694 | M531 3
8388348 | 01 | Nouvelle construction | 1.19806 | 3.87194 | M531 3
8388429 | 01 | Nouvelle construction | 0.0770228 | 3.49204 | M531 3
8388623 | 01 | Nouvelle construction | 1.36527 | 3.51994 | M531 3
8388804 | 01 | Nouvelle construction | 0.909236 | 7.26044 | M531 3
8388808 | 01 | Nouvelle construction | 2.96015 | 7.26044 | M531 3
8388810 | 01 | Nouvelle construction | 0.032 | 7.26194 | M531 3
8388816 | 01 | Nouvelle construction | 1.00936 | 7.26194 | M531 3
8388822 | 01 | Nouvelle construction | 0.539734 | 7.26044 | M531 3
8388824 | 01 | Nouvelle construction | 1.23306 | 7.28194 | M531 3
8388828 | 01 | Nouvelle construction | 1.23306 | 7.28194 | M531 3
8388832 | 01 | Nouvelle construction | 1.26506 | 7.28494 | M531 3
8388844 | 01 | Nouvelle construction | 1.26027 | 7.28494 | M531 3
8388914 | 01 | Nouvelle construction | 0.12775 | 7.25704 | M531 3
8389141 | 01 | Nouvelle construction | 0.137256 | 10.342 | M531 3
8389191 | 01 | Nouvelle construction | 0.0454 | 10.2805 | M531 3
8389259 | 01 | Nouvelle construction | 0.11264 | 7.25704 | M531 3
8391144 | 01 | Nouvelle construction | 0.123555 | 10.342 | M531 3
8391322 | 01 | Nouvelle construction | 3.119 | 10.3454 | M531 3
8391357 | 01 | Nouvelle construction | 1.2342 | 10.3469 | M531 3
8391408 | 01 | Nouvelle construction | 2.858 | 7.26044 | M531 3
8391418 | 01 | Nouvelle construction | 0.077 | 8.8235 | M531 3
8391457 | 01 | Nouvelle construction | 1.63136 | 10.3454 | M531 3
8391756 | 01 | Nouvelle construction | 0.189 | 10.3454 | M531 3
8391845 | 01 | Nouvelle construction | 1.98394 | 8.35 | M531 3
8393559 | 01 | Nouvelle construction | 0.1545 | 10.3454 | M531 3
8393586 | 01 | Nouvelle construction | 0.883445 | 10.342 | M531 3
8393614 | 01 | Nouvelle construction | 0.0795 | 10.4004 | M532F 5
8393654 | 01 | Nouvelle construction | 0.811351 | 10.4004 | M532F 5
8394708 | 01 | Nouvelle construction | 0.115388 | 10.4004 | M532F 5
8394762 | 01 | Nouvelle construction | 0.053 | 10.3454 | M531 3
8394773 | 01 | Nouvelle construction | 0.483796 | 10.3454 | M531 3
8394839 | 01 | Nouvelle construction | 0.05 | 10.3469 | M531 3
8394869 | 01 | Nouvelle construction | 1.77 | 8.56694 | M531 3
8394892 | 01 | Nouvelle construction | 1.33894 | 9.05 | M532F 5
8394929 | 01 | Nouvelle construction | 1.28394 | 9.05 | M531 3
8403020 | 01 | Nouvelle construction | 0.781 | 7.2644 | M5448FF 6
8403030 | 01 | Nouvelle construction | 0.391 | 7.2644 | M5448FF 6
8403064 | 01 | Nouvelle construction | 0.769 | 7.2619 | M5448FF 5
8403074 | 01 | Nouvelle construction | 0.379 | 7.2619 | M5448FF 5
